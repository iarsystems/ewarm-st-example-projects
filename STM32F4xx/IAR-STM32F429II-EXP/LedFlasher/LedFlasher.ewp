# IAR project LedFlasher.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429II ST STM32F429II
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM4; __FPU_PRESENT=1; USE_STDPERIPH_DRIVER; STM32F429X; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ..\..\..\CMSIS\DSP\Include; ; board\; ..\..\STM32F4xx_DSP_StdPeriph_Lib\Libraries\STM32F4xx_StdPeriph_Driver\inc\; ..\..\STM32F4xx_DSP_StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\STM32F4xx_DSP_StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LedFlasher.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: ..\..\..\CMSIS\Lib\IAR\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c readme.txt stm32f4xx_it.c
  group CMSIS
    ../../STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f427x.s
    board/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../STM32F4xx_DSP_StdPeriph_Lib/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c
