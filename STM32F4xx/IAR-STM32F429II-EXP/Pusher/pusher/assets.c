/*******************************************************************************
 *      (c) Copyright IAR System 2013
 *
 *      File name   : assets.c
 *      Description : Holds graphics assets and access functions for the game
 *                    Pusher.
 *
 *      History :
 *      1. Date        : 9, July 2013
 *         Author      : Stefan Risberg
 *         Description : Create
 *
 *      $Revision: 39 $
 ******************************************************************************/
#include <stdint.h>
#include <stdlib.h>
#include "assets.h"

/*******************************************************************************
 ** Function Name : get_bmp_data_asset
 ** Parameters    : asset - Bmp data asset to get.
 ** Returns       : Data associated with asset, otherwise NULL.
 **
 ** Description   : Checks if the bmp data asset exists.
 **                 Its here that you have to add an asset if there is new one.
 ******************************************************************************/
const uint16_t* get_bmp_dat_asset(uint8_t asset);

/* Graphics assets data. */
const uint16_t air_dat[] = {
    0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF,
    0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF,
    0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF,
    0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF,
    0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF,
    0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF,
    0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF,
    0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF,
    0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF, 0x0CEF
};

const uint16_t rock_dat[] = {
    0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888,
    0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888,
    0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888,
    0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888,
    0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888,
    0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888,
    0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888,
    0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888,
    0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888, 0x0888
};

const uint16_t other_dat[] = {
    0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F,
    0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F,
    0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F,
    0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F,
    0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F,
    0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F,
    0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F,
    0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F,
    0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F, 0x0E0F
};
/* End of graphics assets data. */

/* Player assets data. */

const uint16_t player_dat [] = {
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000
};

const uint16_t box_dat[] = {
	0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0,
	0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0,
	0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0,
	0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0,
	0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0,
	0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0,
	0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0,
	0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0,
	0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0, 0x00F0
};

const uint16_t goal_dat[] = {
	0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00,
	0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00,
	0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00,
	0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00,
	0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00,
	0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00,
	0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00,
	0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00,
	0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00, 0x0F00
};
/* End of player assets data. */

/* All bmp assets are present here after init_assets() call. */
BitmapColorType_t bmp_assets[BMP_ASSET_COUNT];

const uint16_t* get_bmp_dat_asset(uint8_t asset)
{
	if ((bmp_asset_t)asset < BMP_ASSET_COUNT) {
		switch((bmp_asset_t)asset) {
		case AIR: return air_dat;
		case ROCK: return rock_dat;
		case PLAYER: return player_dat;
		case BOX: return box_dat;
		case GOAL: return goal_dat;
		case OTHER: return other_dat;
		}
	}
	return NULL;
}

/*******************************************************************************
 ** Function Name : init_assets
 ** Parameters    : none
 ** Returns       : none
 **
 ** Description   : Initializes all assets
 ******************************************************************************/
void init_assets()
{
	for (uint8_t i = 0; i < BMP_ASSET_COUNT; i++) {
		if ((bmp_asset_t)i < BMP_ASSET_COUNT) {
			bmp_assets[i].H_Size = 9;
			bmp_assets[i].V_Size = 9;
			bmp_assets[i].BitsPP = 12;
			bmp_assets[i].BytesPP = 2;
			bmp_assets[i].pPicStream = (uint32_t *)get_bmp_dat_asset(i);
		}
	}
}

/*******************************************************************************
 ** Function Name : get_bmp_asset
 ** Parameters    : asset - What bmp asset to fetch.
 ** Returns       : NULL if asset was not found, otherwise the asset that was
 **                 found.
 **
 ** Description   : Checks if asset exists and returns is.
 ******************************************************************************/
BitmapColorType_t * get_bmp_asset(bmp_asset_t asset)
{
	if (asset < BMP_ASSET_COUNT) {
		return &(bmp_assets[asset]);
	}
	return NULL;
}
