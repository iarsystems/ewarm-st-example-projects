# IAR project Pusher.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429II ST STM32F429II
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429X; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ; utils\; framework\; board\; modules\; ..\..\STM32F4xx_DSP_StdPeriph_Lib\Libraries\STM32F4xx_StdPeriph_Driver\inc\; ..\..\STM32F4xx_DSP_StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\STM32F4xx_DSP_StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Pusher.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c readme.txt stm32f4xx_conf.h
  group BSP
    board/: board_def.c
  group CMSIS
    ../../STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f427x.s
    ../../STM32F4xx_DSP_StdPeriph_Lib/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group framework
    framework/: connect.c gpio.h i2c.h ifpins.h mod.h spi.h uext.h
  group framework/platform
    framework/platform/: platform_config.h stm32_gpio.c stm32_gpio.h stm32_i2c.c stm32_i2c.h
  group modules
    modules/: Console_5x7.c mod_joystick.c mod_lcd6610.c
  group Pusher
    pusher/: assets.c box.c controller.c dimension.c entity.c goal.c map.c player.c pusher.c rect.c render.c vector.c
  group StdPeriph_Driver
    ../../STM32F4xx_DSP_StdPeriph_Lib/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group utils
    utils/: init.c
  group vectors
    ./: stm32f4xx_it.c
