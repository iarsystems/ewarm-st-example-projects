<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DMA_FIFOMode/EWARM/DMA_FIFOMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA_FLASHToRAM/EWARM/DMA_FLASHToRAM.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>DMA_FIFOMode</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>DMA_FLASHToRAM</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
