<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/PWR_CurrentConsumption/EWARM/PWR_CurrentConsumption.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STANDBY/EWARM/PWR_STANDBY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STOP/EWARM/PWR_STOP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>PWR_CurrentConsumption</project>
        <configuration>STM32412ZG_Nucleo</configuration>
      </member>
      <member>
        <project>PWR_STANDBY</project>
        <configuration>STM32412ZG_Nucleo</configuration>
      </member>
      <member>
        <project>PWR_STOP</project>
        <configuration>STM32412ZG_Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
