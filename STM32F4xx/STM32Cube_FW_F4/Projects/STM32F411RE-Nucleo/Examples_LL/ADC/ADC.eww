<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_AnalogWatchdog/EWARM/ADC_AnalogWatchdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_ContinuousConversion_TriggerSW/EWARM/ADC_ContinuousConversion_TriggerSW.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_ContinuousConversion_TriggerSW_Init/EWARM/ADC_ContinuousConversion_TriggerSW_Init.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_GroupsRegularInjected/EWARM/ADC_GroupsRegularInjected.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_MultiChannelSingleConversion/EWARM/ADC_MultiChannelSingleConversion.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_SingleConversion_TriggerSW/EWARM/ADC_SingleConversion_TriggerSW.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_SingleConversion_TriggerSW_DMA/EWARM/ADC_SingleConversion_TriggerSW_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_SingleConversion_TriggerSW_IT/EWARM/ADC_SingleConversion_TriggerSW_IT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_SingleConversion_TriggerTimer_DMA/EWARM/ADC_SingleConversion_TriggerTimer_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_TemperatureSensor/EWARM/ADC_TemperatureSensor.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_AnalogWatchdog</project>
        <configuration>STM32F411-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_ContinuousConversion_TriggerSW</project>
        <configuration>STM32F411-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_ContinuousConversion_TriggerSW_Init</project>
        <configuration>STM32F411-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_GroupsRegularInjected</project>
        <configuration>STM32F411-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_MultiChannelSingleConversion</project>
        <configuration>STM32F411-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_SingleConversion_TriggerSW</project>
        <configuration>STM32F411-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_SingleConversion_TriggerSW_DMA</project>
        <configuration>STM32F411-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_SingleConversion_TriggerSW_IT</project>
        <configuration>STM32F411-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_SingleConversion_TriggerTimer_DMA</project>
        <configuration>STM32F411-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_TemperatureSensor</project>
        <configuration>STM32F411-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
