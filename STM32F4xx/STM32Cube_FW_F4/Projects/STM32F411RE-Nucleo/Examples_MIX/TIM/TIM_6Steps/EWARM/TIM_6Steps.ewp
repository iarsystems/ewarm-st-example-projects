# IAR project TIM_6Steps.ewp, settings and files
configuration STM32F411-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; USE_STM32F4XX_NUCLEO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F411-Nucleo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Example/EWARM
    ./: startup_stm32f411xe.s
  group Example/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
