<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/FMPI2C_EEPROM/EWARM/FMPI2C_EEPROM.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>FMPI2C_EEPROM</project>
        <configuration>STM32446E_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
