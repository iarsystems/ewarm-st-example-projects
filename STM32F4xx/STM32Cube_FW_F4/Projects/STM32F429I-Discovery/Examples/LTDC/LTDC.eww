<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/LTDC_Display_2Layers/EWARM/LTDC_Display_2Layers.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>LTDC_Display_2Layers</project>
        <configuration>STM32F429I-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
