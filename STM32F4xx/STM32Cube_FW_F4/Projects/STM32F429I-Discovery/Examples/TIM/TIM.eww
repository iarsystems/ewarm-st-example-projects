<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TIM_PWMInput/EWARM/TIM_PWMInput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_TimeBase/EWARM/TIM_TimeBase.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TIM_PWMInput</project>
        <configuration>STM32F429I-Discovery</configuration>
      </member>
      <member>
        <project>TIM_TimeBase</project>
        <configuration>STM32F429I-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
