<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RTC_Alarm/EWARM/RTC_Alarm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RTC_Calendar/EWARM/RTC_Calendar.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RTC_Tamper/EWARM/RTC_Tamper.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RTC_TimeStamp/EWARM/RTC_TimeStamp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RTC_Alarm</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>RTC_Calendar</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>RTC_Tamper</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>RTC_TimeStamp</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
