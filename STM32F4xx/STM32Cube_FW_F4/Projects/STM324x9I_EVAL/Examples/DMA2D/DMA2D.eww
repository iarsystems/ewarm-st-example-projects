<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DMA2D_MemoryToMemory/EWARM/DMA2D_MemoryToMemory.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA2D_MemToMemWithBlending/EWARM/DMA2D_MemToMemWithBlending.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA2D_MemToMemWithLCD/EWARM/DMA2D_MemToMemWithLCD.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA2D_MemToMemWithPFC/EWARM/DMA2D_MemToMemWithPFC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA2D_RegToMemWithLCD/EWARM/DMA2D_RegToMemWithLCD.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>DMA2D_MemoryToMemory</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>DMA2D_MemToMemWithBlending</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>DMA2D_MemToMemWithLCD</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>DMA2D_MemToMemWithPFC</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>DMA2D_RegToMemWithLCD</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
