# IAR project CORTEXM_ModePrivilege.ewp, settings and files
configuration STM324x9I_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM324x9I_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c
  group Example/EWARM
    ./: startup_stm32f429xx.s
  group Example/User
    ../Src/: main.c stm32f4xx_it.c
