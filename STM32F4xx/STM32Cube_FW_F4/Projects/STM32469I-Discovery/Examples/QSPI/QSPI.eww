<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/QSPI_ExecuteInPlace/EWARM/QSPI_ExecuteInPlace.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/QSPI_PreInitConfig/EWARM/QSPI_PreInitConfig.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>QSPI_ExecuteInPlace</project>
        <configuration>STM32469I_DISCOVERY</configuration>
      </member>
      <member>
        <project>QSPI_PreInitConfig</project>
        <configuration>STM32469I_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
