<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/GPIO_EXTI/EWARM/GPIO_EXTI.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>GPIO_EXTI</project>
        <configuration>STM32469I_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
