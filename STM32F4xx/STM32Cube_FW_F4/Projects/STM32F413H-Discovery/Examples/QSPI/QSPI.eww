<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/QSPI_ReadWrite_DMA/EWARM/QSPI_ReadWrite_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/QSPI_ReadWrite_IT/EWARM/QSPI_ReadWrite_IT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>QSPI_ReadWrite_DMA</project>
        <configuration>STM32F413H_DISCOVERY</configuration>
      </member>
      <member>
        <project>QSPI_ReadWrite_IT</project>
        <configuration>STM32F413H_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
