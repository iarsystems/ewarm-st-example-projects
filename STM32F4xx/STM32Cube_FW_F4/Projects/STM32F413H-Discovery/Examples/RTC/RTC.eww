<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RTC_Calendar/EWARM/RTC_Calendar.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RTC_TimeStamp/EWARM/RTC_TimeStamp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RTC_Calendar</project>
        <configuration>STM32F413H_DISCOVERY</configuration>
      </member>
      <member>
        <project>RTC_TimeStamp</project>
        <configuration>STM32F413H_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
