<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DFSDM_PulseSkipper/EWARM/DFSDM_PulseSkipper.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>DFSDM_PulseSkipper</project>
        <configuration>STM32F413H-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
