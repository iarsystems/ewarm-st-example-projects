<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TIM_PWMInput/EWARM/TIM_PWMInput.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TIM_PWMInput</project>
        <configuration>STM32F410xx-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
