# IAR project Template_LL.ewp, settings and files
configuration NUCLEO-F410Cx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F410CB ST STM32F410CB
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F410Cx; USE_FULL_LL_DRIVER; HSE_VALUE=8000000U
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NUCLEO-F410Cx.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f410cx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NUCLEO-F410Rx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F410RB ST STM32F410RB
  ICCARM.CCDefines: STM32F410Rx; USE_FULL_LL_DRIVER; HSE_VALUE=8000000U
  OBJCOPY.OOCOutputFile: NUCLEO-F410Rx.hex
  ILINK.IlinkIcfFile: stm32f410rx_flash.icf
configuration NUCLEO-F410Tx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F410TB ST STM32F410TB
  ICCARM.CCDefines: STM32F410Tx; USE_FULL_LL_DRIVER; HSE_VALUE=8000000U
  OBJCOPY.OOCOutputFile: NUCLEO-F410Tx.hex
  ILINK.IlinkIcfFile: stm32f410tx_flash.icf
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_LL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
  group Example/EWARM
    ./: startup_stm32f410cx.s startup_stm32f410rx.s startup_stm32f410tx.s
  group Example/User
    ../Src/: main.c stm32f4xx_it.c
