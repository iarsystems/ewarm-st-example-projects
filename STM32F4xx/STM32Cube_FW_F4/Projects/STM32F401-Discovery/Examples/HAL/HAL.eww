<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/HAL_TimeBase_RTC_ALARM/EWARM/HAL_TimeBase_RTC_ALARM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HAL_TimeBase_RTC_WKUP/EWARM/HAL_TimeBase_RTC_WKUP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HAL_TimeBase_TIM/EWARM/HAL_TimeBase_TIM.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>HAL_TimeBase_RTC_ALARM</project>
        <configuration>STM32F401-Discovery</configuration>
      </member>
      <member>
        <project>HAL_TimeBase_RTC_WKUP</project>
        <configuration>STM32F401-Discovery</configuration>
      </member>
      <member>
        <project>HAL_TimeBase_TIM</project>
        <configuration>STM32F401-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
