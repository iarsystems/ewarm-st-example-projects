<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Template_LL.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>Template_LL</project>
        <configuration>STM32469I-EVAL</configuration>
      </member>
      <member>
        <project>Template_LL</project>
        <configuration>STM32479I-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
