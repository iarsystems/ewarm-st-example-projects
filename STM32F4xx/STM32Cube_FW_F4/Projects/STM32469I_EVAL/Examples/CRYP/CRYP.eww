<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CRYP_AESModes/EWARM/CRYP_AESModes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_AES_CCM/EWARM/CRYP_AES_CCM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_AES_DMA/EWARM/CRYP_AES_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_AES_GCM/EWARM/CRYP_AES_GCM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_DESTDESmodes/EWARM/CRYP_DESTDESmodes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_TDES_DMA/EWARM/CRYP_TDES_DMA.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CRYP_AESModes</project>
        <configuration>STM32479I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AES_CCM</project>
        <configuration>STM32479I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AES_DMA</project>
        <configuration>STM32479I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AES_GCM</project>
        <configuration>STM32479I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_DESTDESmodes</project>
        <configuration>STM32479I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_TDES_DMA</project>
        <configuration>STM32479I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
