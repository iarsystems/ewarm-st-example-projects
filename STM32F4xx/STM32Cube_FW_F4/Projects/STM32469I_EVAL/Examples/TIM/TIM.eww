<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TIM_6Steps/EWARM/TIM_6Steps.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_7PWMOutput/EWARM/TIM_7PWMOutput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_CascadeSynchro/EWARM/TIM_CascadeSynchro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_ComplementarySignals/EWARM/TIM_ComplementarySignals.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_DMA/EWARM/TIM_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_DMABurst/EWARM/TIM_DMABurst.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_Encoder/EWARM/TIM_Encoder.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_ExtTriggerSynchro/EWARM/TIM_ExtTriggerSynchro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_InputCapture/EWARM/TIM_InputCapture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_OCActive/EWARM/TIM_OCActive.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_OCInactive/EWARM/TIM_OCInactive.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_OCToggle/EWARM/TIM_OCToggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_OnePulse/EWARM/TIM_OnePulse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_ParallelSynchro/EWARM/TIM_ParallelSynchro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PrescalerSelection/EWARM/TIM_PrescalerSelection.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PWMInput/EWARM/TIM_PWMInput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PWMOutput/EWARM/TIM_PWMOutput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_Synchronization/EWARM/TIM_Synchronization.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_TimeBase/EWARM/TIM_TimeBase.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TIM_6Steps</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_7PWMOutput</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_CascadeSynchro</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_ComplementarySignals</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_DMA</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_DMABurst</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_Encoder</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_ExtTriggerSynchro</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_InputCapture</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_OCActive</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_OCInactive</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_OCToggle</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_OnePulse</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_ParallelSynchro</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_PrescalerSelection</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_PWMInput</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_PWMOutput</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_Synchronization</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
      <member>
        <project>TIM_TimeBase</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
