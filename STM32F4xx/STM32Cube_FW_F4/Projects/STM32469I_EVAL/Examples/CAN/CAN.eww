<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CAN_Loopback/EWARM/CAN_Loopback.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CAN_Loopback</project>
        <configuration>STM32469I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
