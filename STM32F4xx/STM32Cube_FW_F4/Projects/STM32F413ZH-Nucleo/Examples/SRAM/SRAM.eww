<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SRAM_ExecuteInPlace/EWARM/SRAM_ExecuteInPlace.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SRAM_ExecuteInPlace</project>
        <configuration>STM32413ZH_Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
