<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TIM_DMA/EWARM/TIM_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_InputCapture/EWARM/TIM_InputCapture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_OCActive/EWARM/TIM_OCActive.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_OCToggle/EWARM/TIM_OCToggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_OnePulse/EWARM/TIM_OnePulse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PWMInput/EWARM/TIM_PWMInput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PWMOutput/EWARM/TIM_PWMOutput.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TIM_DMA</project>
        <configuration>STM32412G_DISCOVERY</configuration>
      </member>
      <member>
        <project>TIM_InputCapture</project>
        <configuration>STM32412G_DISCOVERY</configuration>
      </member>
      <member>
        <project>TIM_OCActive</project>
        <configuration>STM32412G_DISCOVERY</configuration>
      </member>
      <member>
        <project>TIM_OCToggle</project>
        <configuration>STM32412G_DISCOVERY</configuration>
      </member>
      <member>
        <project>TIM_OnePulse</project>
        <configuration>STM32412G_DISCOVERY</configuration>
      </member>
      <member>
        <project>TIM_PWMInput</project>
        <configuration>STM32412G_DISCOVERY</configuration>
      </member>
      <member>
        <project>TIM_PWMOutput</project>
        <configuration>STM32412G_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
