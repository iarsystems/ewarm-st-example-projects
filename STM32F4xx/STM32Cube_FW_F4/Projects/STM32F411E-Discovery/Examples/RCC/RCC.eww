<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RCC_ClockConfig/EWARM/RCC_ClockConfig.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RCC_ClockConfig</project>
        <configuration>STM32F411E-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
