<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_DMA/EWARM/ADC_RegularConversion_DMA.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_RegularConversion_DMA</project>
        <configuration>STM32F411E-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
