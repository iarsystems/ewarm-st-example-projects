<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Morse_Code_Recorder.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Morse_Code_Recorder</project>
        <configuration>Flash Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
