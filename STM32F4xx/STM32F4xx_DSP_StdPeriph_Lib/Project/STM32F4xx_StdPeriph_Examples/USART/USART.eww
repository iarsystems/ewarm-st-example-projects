<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/USART_TwoBoards/DataExchangeDMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_TwoBoards/DataExchangeInterrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HyperTerminal/HyperTerminal.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_Printf/USART_Printf.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>DataExchangeDMA</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>DataExchangeDMA</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>DataExchangeInterrupt</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>DataExchangeInterrupt</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>USART_Printf</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>USART_Printf</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
