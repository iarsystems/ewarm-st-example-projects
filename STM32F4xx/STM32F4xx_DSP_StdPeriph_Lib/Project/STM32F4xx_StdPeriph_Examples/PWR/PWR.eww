<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/BOR/BOR.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CurrentConsumption/CurrentConsumption.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PVD/PVD.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/STANDBY/STANDBY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/STOP/STOP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>BOR</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>BOR</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>BOR</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>CurrentConsumption</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>CurrentConsumption</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>PVD</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>PVD</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>PVD</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>STANDBY</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>STANDBY</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>STANDBY</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>STOP</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>STOP</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>STOP</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
