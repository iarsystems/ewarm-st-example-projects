<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Program/Program.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/WriteProtection/Write_Protection.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Program</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>Program</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>Program</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>Write_Protection</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>Write_Protection</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>Write_Protection</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
