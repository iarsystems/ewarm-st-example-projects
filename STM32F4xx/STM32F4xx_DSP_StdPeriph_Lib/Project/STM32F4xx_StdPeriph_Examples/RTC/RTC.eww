<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/BKP_Domain/BKP_Domain.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Calendar/Calendar.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LSI/LSI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/StopWatch/StopWatch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Tamper/Tamper.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Timer/Timer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TimeStamp/TimeStamp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>BKP_Domain</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>BKP_Domain</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>Calendar</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>Calendar</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>LSI</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>LSI</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>StopWatch</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>StopWatch</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>Tamper</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>Tamper</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>Timer</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>Timer</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>TimeStamp</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>TimeStamp</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
