<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CRYP_AES_CCM/CRYP_AES_CCM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_AES_GCM/CRYP_AES_GCM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_AESECBmode/CRYP_AESECBmode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_AESmodes/CRYP_AESmodes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_DESTDESmodes/CRYP_DESTDESmodes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_TDESECBmode/CRYP_TDESECBmode.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>CRYP_AES_CCM</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AES_CCM</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AES_CCM</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AES_GCM</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AES_GCM</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AES_GCM</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AESECBmode</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AESECBmode</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AESECBmode</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AESmodes</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AESmodes</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AESmodes</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_DESTDESmodes</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_DESTDESmodes</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_DESTDESmodes</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_TDESECBmode</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_TDESECBmode</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_TDESECBmode</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
