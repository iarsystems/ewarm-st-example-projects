<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Audio/Audio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TwoBoards/DataExchangePolling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Audio</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>Audio</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>Audio</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>DataExchangePolling</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>DataExchangePolling</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
