<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/WFI_Mode/DMA_WFIMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/IRQ_Mask/IRQ_Mask.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/IRQ_Priority/IRQ_Priority.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/VectorTableRelocation/VectorTable_Relocation.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>DMA_WFIMode</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>DMA_WFIMode</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>DMA_WFIMode</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>IRQ_Mask</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>IRQ_Mask</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>IRQ_Mask</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>IRQ_Priority</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>IRQ_Priority</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>IRQ_Priority</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>VectorTable_Relocation</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>VectorTable_Relocation</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>VectorTable_Relocation</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
