<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/FLASH_RAM/FLASH_RAM.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>FLASH_RAM</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>FLASH_RAM</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>FLASH_RAM</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
