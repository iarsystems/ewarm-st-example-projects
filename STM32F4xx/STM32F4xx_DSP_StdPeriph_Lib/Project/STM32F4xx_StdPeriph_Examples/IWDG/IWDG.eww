<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/IWDG_Example/IWDG_Example.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>IWDG_Example</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>IWDG_Example</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>IWDG_Example</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
