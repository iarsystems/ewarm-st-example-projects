<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/LoopBack/CAN_LoopBack.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Networking/CAN_Networking.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>CAN_LoopBack</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>CAN_LoopBack</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>CAN_Networking</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>CAN_Networking</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
