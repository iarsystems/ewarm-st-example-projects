<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/HASH_ContextSwap/Context_Swap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HASH_SHA1MD5/HASH_SHA1MD5.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HMAC_SHA1MD5/HMAC_SHA1MD5.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SHA1_MD5_DMA/SHA1_MD5_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SHA224_SHA256_DMA/SHA224_SHA256_DMA.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Context_Swap</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>Context_Swap</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>Context_Swap</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>HASH_SHA1MD5</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>HASH_SHA1MD5</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>HASH_SHA1MD5</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>HMAC_SHA1MD5</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>HMAC_SHA1MD5</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>HMAC_SHA1MD5</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>SHA1_MD5_DMA</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>SHA1_MD5_DMA</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>SHA1_MD5_DMA</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>SHA224_SHA256_DMA</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>SHA224_SHA256_DMA</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>SHA224_SHA256_DMA</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
