<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/NOR/NOR.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SDRAM/SDRAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SDRAM_Basic/SDRAM_Basic.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SDRAM_DataMemory/SDRAM_DataMemory.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SDRAM_DMA/SDRAM_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SDRAM_LowPower/SDRAM_LowPower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SDRAM_SRAM_BankSwitch/SDRAM_SRAM_BankSwitch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SRAM/SRAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SRAM_DataMemory/SRAM_DataMemory.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>NOR</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>SDRAM</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>SDRAM_Basic</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>SDRAM_DataMemory</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>SDRAM_DMA</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>SDRAM_LowPower</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>SDRAM_SRAM_BankSwitch</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>SRAM</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>SRAM</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>SRAM</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>SRAM_DataMemory</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>SRAM_DataMemory</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>SRAM_DataMemory</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
