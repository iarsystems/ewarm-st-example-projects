<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_DMA/ADC3_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DualModeInterleaved/DualADC_Interleaved.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DualModeRegulSimu/DualADC_RegulSimu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_TripleModeInterleaved/TripleADC_Interleaved.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_VBATMeasurement/VBAT_Measurement.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>ADC3_DMA</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>ADC3_DMA</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>ADC3_DMA</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>DualADC_Interleaved</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>DualADC_Interleaved</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>DualADC_Interleaved</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>DualADC_RegulSimu</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>DualADC_RegulSimu</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>DualADC_RegulSimu</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>TripleADC_Interleaved</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>TripleADC_Interleaved</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>TripleADC_Interleaved</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>VBAT_Measurement</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>VBAT_Measurement</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>VBAT_Measurement</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
