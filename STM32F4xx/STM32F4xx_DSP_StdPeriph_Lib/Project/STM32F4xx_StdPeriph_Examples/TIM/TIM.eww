<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/6Steps/6Steps.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/7PWM_Output/7PWM_Output.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CascadeSynchro/CascadeSynchro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ComplementarySignals/ComplementarySignals.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA/DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA_Burst/DMABurst.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ExtTriggerSynchro/ExtTriggerSynchro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/InputCapture/InputCapture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OC_Active/OC_Active.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OC_Inactive/OC_Inactive.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OC_Toggle/OC_Toggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OnePulse/OnePulse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ParallelSynchro/ParallelSynchro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWM_Input/PWM_Input.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWM_Output/PWM_Output.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM10_PWM_Output/TIM10_PWM_Output.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM1_Synchro/TIM1_Synchro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM9_OC_Toggle/TIM9_OC_Toggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TimeBase/TimeBase.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>6Steps</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>6Steps</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>7PWM_Output</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>7PWM_Output</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>CascadeSynchro</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>CascadeSynchro</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>ComplementarySignals</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>ComplementarySignals</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>DMABurst</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>DMABurst</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>ExtTriggerSynchro</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>ExtTriggerSynchro</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>InputCapture</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>InputCapture</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>OC_Active</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>OC_Active</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>OC_Inactive</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>OC_Inactive</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>OC_Toggle</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>OC_Toggle</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>OnePulse</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>OnePulse</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>ParallelSynchro</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>ParallelSynchro</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>PWM_Input</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>PWM_Input</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>PWM_Output</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>PWM_Output</project>
        <configuration>STM324x9I_EVAL</configuration>
      </member>
      <member>
        <project>PWM_Output</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>TIM1_Synchro</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>TIM1_Synchro</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>TIM10_PWM_Output</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>TIM10_PWM_Output</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>TIM9_OC_Toggle</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>TIM9_OC_Toggle</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
      <member>
        <project>TimeBase</project>
        <configuration>STM324x7I_EVAL</configuration>
      </member>
      <member>
        <project>TimeBase</project>
        <configuration>STM324xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
