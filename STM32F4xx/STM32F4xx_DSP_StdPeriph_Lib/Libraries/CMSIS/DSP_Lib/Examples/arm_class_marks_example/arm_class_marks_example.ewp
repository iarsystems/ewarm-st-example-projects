# IAR project arm_class_marks_example.ewp, settings and files
configuration Cortex_M4 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4
  ICCARM.CCDiagSuppress: Pa093
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\CMSIS\DSP\Include; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: arm_class_marks_example.out
  ILINK.IlinkIcfFile: ../CONFIG/generic_cortex.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\CMSIS\Lib\IAR\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: arm_class_marks_example_f32.c
