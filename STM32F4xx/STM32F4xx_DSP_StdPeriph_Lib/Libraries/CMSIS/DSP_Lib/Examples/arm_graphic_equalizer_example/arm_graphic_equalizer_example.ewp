# IAR project arm_graphic_equalizer_example.ewp, settings and files
configuration Cortex_M4 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4
  ICCARM.CCDiagSuppress: Pa093
  ICCARM.CCIncludePath2: ..\Common\Include\; ..\..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\CMSIS\DSP\Include; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../CONFIG/generic_cortex.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\CMSIS\Lib\IAR\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: arm_graphic_equalizer_data.c arm_graphic_equalizer_example_q31.c
    ../Common/Source/: math_helper.c
