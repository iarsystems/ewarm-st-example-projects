# IAR project TouchScreen.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429II ST STM32F429II
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429X; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; app\; modules\; board\; ..\..\STM32F4xx_DSP_StdPeriph_Lib\Libraries\STM32F4xx_StdPeriph_Driver\inc\; ..\..\STM32F4xx_DSP_StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32F4xx\Include\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TempSensor.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    app/: iosys.c main.c stm32f4xx_it.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group board
    board/: iar_stm32f429ii_sk.c
  group modules
    modules/: drv_glcd.c drv_glcd_lodepng.c drv_touch_scr.c i2c2_drv.c lodepng.c sdram_32M_16bit_drv.c
  group startup
    startup/: startup_stm32f429x.s system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../STM32F4xx_DSP_StdPeriph_Lib/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
