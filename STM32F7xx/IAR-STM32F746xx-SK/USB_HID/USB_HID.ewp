# IAR project USB_HID.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; HSE_VALUE=8000000; USE_USB_HS
  ICCARM.CCIncludePath2: ; app\; modules\; board\; USB_app\; ..\..\Libraries\STM32F7xx_HAL_Driver\inc\; ..\..\Libraries\CMSIS\Device\ST\STM32F7xx\Include\; ..\..\Libraries\STM32_USB_Device_Library\Core\inc\; ..\..\Libraries\STM32_USB_Device_Library\Class\HID\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/stm32f7xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    app/: iosys.c main.c stm32f7xx_it.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group board
    board/: iar_stm32f746xx_sk.c
  group modules
    modules/: drv_glcd.c drv_glcd_lodepng.c lodepng.c mpu.c sdram_32M_16bit_drv.c
  group startup
    startup/: startup_stm32f746xx.s system_stm32f7xx.c
  group STM32_USB_Device_Library/Class/HID
    ../../Libraries/STM32_USB_Device_Library/Class/HID/src/: usbd_hid.c
  group STM32_USB_Device_Library/Core
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group STM32F7xx_HAL_Drivers
    ../../Libraries/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group USB_app
    USB_app/: usbd_conf.c usbd_desc.c
