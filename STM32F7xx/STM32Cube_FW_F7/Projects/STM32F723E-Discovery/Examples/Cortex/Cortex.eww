<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CORTEXM_MPU/EWARM/CORTEXM_MPU.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CORTEXM_ProcessStack/EWARM/CORTEXM_ProcessStack.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CORTEXM_SysTick/EWARM/CORTEXM_SysTick.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CORTEXM_MPU</project>
        <configuration>STM32F723E_DISCOVERY</configuration>
      </member>
      <member>
        <project>CORTEXM_ProcessStack</project>
        <configuration>STM32F723E_DISCOVERY</configuration>
      </member>
      <member>
        <project>CORTEXM_SysTick</project>
        <configuration>STM32F723E_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
