<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/FLASH_EraseProgram/EWARM/FLASH_EraseProgram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FLASH_PcropProtection/EWARM/FLASH_PcropProtection.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FLASH_WriteProtection/EWARM/FLASH_WriteProtection.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>FLASH_EraseProgram</project>
        <configuration>STM32F723E_DISCOVERY</configuration>
      </member>
      <member>
        <project>FLASH_PcropProtection</project>
        <configuration>STM32F723E_DISCOVERY</configuration>
      </member>
      <member>
        <project>FLASH_WriteProtection</project>
        <configuration>STM32F723E_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
