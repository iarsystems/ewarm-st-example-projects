<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/QSPI_ReadWrite/EWARM/QSPI_ReadWrite.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>QSPI_ReadWrite</project>
        <configuration>STM32F723E-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
