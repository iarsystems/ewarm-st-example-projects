<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/I2C_TwoBoards_RestartAdvComIT/EWARM/I2C_TwoBoards_RestartAdvComIT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_TwoBoards_RestartComIT/EWARM/I2C_TwoBoards_RestartComIT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>I2C_TwoBoards_RestartAdvComIT</project>
        <configuration>STM32F767ZI-Nucleo</configuration>
      </member>
      <member>
        <project>I2C_TwoBoards_RestartComIT</project>
        <configuration>STM32F767ZI-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
