<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/FLASH_EraseProgram/EWARM/FLASH_EraseProgram.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FLASH_SwapBank/EWARM/FLASH_SwapBank.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>FLASH_EraseProgram</project>
        <configuration>STM32F767ZI-Nucleo</configuration>
      </member>
      <member>
        <project>FLASH_SwapBank</project>
        <configuration>FLASH_SwapBank_Bank1</configuration>
      </member>
      <member>
        <project>FLASH_SwapBank</project>
        <configuration>FLASH_SwapBank_Bank2</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
