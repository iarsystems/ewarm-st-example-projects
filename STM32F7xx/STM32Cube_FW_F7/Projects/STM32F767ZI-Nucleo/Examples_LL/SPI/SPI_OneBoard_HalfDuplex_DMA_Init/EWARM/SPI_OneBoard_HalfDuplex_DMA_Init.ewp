# IAR project SPI_OneBoard_HalfDuplex_DMA_Init.ewp, settings and files
configuration STM32F767ZI-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 7
  ICCARM.CCDefines: STM32F767xx; USE_STM32F7XX_NUCLEO_144; USE_FULL_LL_DRIVER; HSE_VALUE=8000000U
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F767ZI-Nucleo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32f7xx_it.c
  group Example/EWARM
    ./: startup_stm32f767xx.s
  group Drivers/STM32F7xx_LL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_utils.c stm32f7xx_ll_spi.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rcc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
