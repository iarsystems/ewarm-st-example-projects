<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/UTILS_ConfigureSystemClock/EWARM/UTILS_ConfigureSystemClock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UTILS_ReadDeviceInfo/EWARM/UTILS_ReadDeviceInfo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>UTILS_ConfigureSystemClock</project>
        <configuration>STM32F767ZI-Nucleo</configuration>
      </member>
      <member>
        <project>UTILS_ReadDeviceInfo</project>
        <configuration>STM32F767ZI-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
