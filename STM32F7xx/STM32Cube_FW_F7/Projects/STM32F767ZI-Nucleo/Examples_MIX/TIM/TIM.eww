<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TIM_6Steps/EWARM/TIM_6Steps.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PWMInput/EWARM/TIM_PWMInput.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TIM_6Steps</project>
        <configuration>NUCLEO-F767ZI</configuration>
      </member>
      <member>
        <project>TIM_PWMInput</project>
        <configuration>NUCLEO-F767ZI</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
