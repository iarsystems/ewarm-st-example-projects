<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TIM_TimeBase/EWARM/TIM_TimeBase.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TIM_TimeBase</project>
        <configuration>STM32F722ZE_Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
