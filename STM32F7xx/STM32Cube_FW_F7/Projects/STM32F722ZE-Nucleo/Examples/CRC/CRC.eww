<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CRC_Bytes_Stream_7bit_CRC/EWARM/CRC_Bytes_Stream_7bit_CRC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRC_Example/EWARM/CRC_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRC_UserDefinedPolynomial/EWARM/CRC_UserDefinedPolynomial.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CRC_Bytes_Stream_7bit_CRC</project>
        <configuration>STM32F722ZE_Nucleo</configuration>
      </member>
      <member>
        <project>CRC_Example</project>
        <configuration>STM32F722ZE_Nucleo</configuration>
      </member>
      <member>
        <project>CRC_UserDefinedPolynomial</project>
        <configuration>STM32F722ZE_Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
