<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RTC_TimeStamp/EWARM/RTC_TimeStamp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RTC_TimeStamp</project>
        <configuration>STM32F722ZE_Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
