<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/UART_TwoBoards_ComDMA/EWARM/UART_TwoBoards_ComDMA.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>UART_TwoBoards_ComDMA</project>
        <configuration>STM32F722ZE_Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
