<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/FLASH_EraseProgram/EWARM/FLASH_EraseProgram.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>FLASH_EraseProgram</project>
        <configuration>STM32F722ZE_Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
