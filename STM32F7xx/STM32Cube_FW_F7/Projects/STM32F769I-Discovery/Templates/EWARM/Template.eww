<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Template.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>Template</project>
        <configuration>STM32F769I_DISCOVERY_AXIM-FLASH</configuration>
      </member>
      <member>
        <project>Template</project>
        <configuration>STM32F769I_DISCOVERY_ITCM-FLASH</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
