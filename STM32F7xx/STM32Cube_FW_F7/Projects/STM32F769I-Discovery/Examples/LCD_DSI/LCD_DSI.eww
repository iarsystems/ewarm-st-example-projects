<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/LCD_DSI_CmdMode_DoubleBuffer/EWARM/LCD_DSI_CmdMode_DoubleBuffer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_DSI_CmdMode_PartialRefresh/EWARM/LCD_DSI_CmdMode_PartialRefresh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_DSI_VideoMode_DoubleBuffering/EWARM/LCD_DSI_VideoMode_DoubleBuffering.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_DSI_VideoMode_SingleBuffer/EWARM/LCD_DSI_VideoMode_SingleBuffer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>LCD_DSI_CmdMode_DoubleBuffer</project>
        <configuration>STM32F769I_DISCOVERY</configuration>
      </member>
      <member>
        <project>LCD_DSI_CmdMode_PartialRefresh</project>
        <configuration>STM32F769I_DISCOVERY</configuration>
      </member>
      <member>
        <project>LCD_DSI_VideoMode_DoubleBuffering</project>
        <configuration>STM32F769I_DISCOVERY</configuration>
      </member>
      <member>
        <project>LCD_DSI_VideoMode_SingleBuffer</project>
        <configuration>STM32F769I_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
