<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_TemperatureSensor/EWARM/ADC_TemperatureSensor.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_TemperatureSensor</project>
        <configuration>STM32F769I_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
