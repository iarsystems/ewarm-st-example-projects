<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/FMC_SDRAM/EWARM/FMC_SDRAM.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>FMC_SDRAM</project>
        <configuration>STM32F769I_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
