<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SPI_FullDuplex_ComDMA/EWARM/SPI_FullDuplex_ComDMA.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SPI_FullDuplex_ComDMA</project>
        <configuration>STM32F769I_Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
