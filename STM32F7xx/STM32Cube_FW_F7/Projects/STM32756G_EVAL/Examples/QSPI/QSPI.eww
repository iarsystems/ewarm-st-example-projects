<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/QSPI_ExecuteInPlace/EWARM/QSPI_ExecuteInPlace.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/QSPI_MemoryMapped/EWARM/QSPI_MemoryMapped.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/QSPI_PreInitConfig/EWARM/QSPI_PreInitConfig.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/QSPI_ReadWrite_DMA/EWARM/QSPI_ReadWrite_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/QSPI_ReadWrite_IT/EWARM/QSPI_ReadWrite_IT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>QSPI_ExecuteInPlace</project>
        <configuration>STM327x6G_EVAL</configuration>
      </member>
      <member>
        <project>QSPI_MemoryMapped</project>
        <configuration>STM327x6G_EVAL</configuration>
      </member>
      <member>
        <project>QSPI_PreInitConfig</project>
        <configuration>STM327x6G-EVAL</configuration>
      </member>
      <member>
        <project>QSPI_ReadWrite_DMA</project>
        <configuration>STM327x6G_EVAL</configuration>
      </member>
      <member>
        <project>QSPI_ReadWrite_IT</project>
        <configuration>STM327x6G_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
