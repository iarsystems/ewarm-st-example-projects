<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/I2C_EEPROM_FM+/EWARM/I2C_EEPROM_FM+.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>I2C_EEPROM_FM+</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
