<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/LCD_DSI_CmdMode_DoubleBuffer/EWARM/LCD_DSI_CmdMode_DoubleBuffer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_DSI_CmdMode_PartialRefresh/EWARM/LCD_DSI_CmdMode_PartialRefresh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_DSI_CmdMode_SingleBuffer/EWARM/LCD_DSI_CmdMode_SingleBuffer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_DSI_CmdMode_TearingEffect/EWARM/LCD_DSI_CmdMode_TearingEffect.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_DSI_CmdMode_TearingEffect_ExtPin/EWARM/LCD_DSI_CmdMode_TearingEffect_ExtPin.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_DSI_ULPM_Data/EWARM/LCD_DSI_ULPM_Data.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_DSI_ULPM_DataClock/EWARM/LCD_DSI_ULPM_DataClock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_DSI_VideoMode_DoubleBuffering/EWARM/LCD_DSI_VideoMode_DoubleBuffering.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_DSI_VideoMode_SingleBuffer/EWARM/LCD_DSI_VideoMode_SingleBuffer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>LCD_DSI_CmdMode_DoubleBuffer</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>LCD_DSI_CmdMode_PartialRefresh</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>LCD_DSI_CmdMode_SingleBuffer</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>LCD_DSI_CmdMode_TearingEffect</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>LCD_DSI_CmdMode_TearingEffect_ExtPin</project>
        <configuration>LCD_DSI_CmdMode_TearingEffect_ExtPin</configuration>
      </member>
      <member>
        <project>LCD_DSI_ULPM_Data</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>LCD_DSI_ULPM_DataClock</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>LCD_DSI_VideoMode_DoubleBuffering</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>LCD_DSI_VideoMode_SingleBuffer</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
