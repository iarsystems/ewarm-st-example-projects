<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CAN_Loopback/EWARM/CAN_Loopback.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CAN_Networking/EWARM/CAN_Networking.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CAN_Loopback</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>CAN_Networking</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
