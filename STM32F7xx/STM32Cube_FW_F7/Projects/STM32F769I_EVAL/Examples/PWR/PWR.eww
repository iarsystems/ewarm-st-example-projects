<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/PWR_STANDBY_RTC/EWARM/PWR_STANDBY_RTC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STOP_RTC/EWARM/PWR_STOP_RTC.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>PWR_STANDBY_RTC</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>PWR_STOP_RTC</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
