<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_DualModeInterleaved/EWARM/ADC_DualModeInterleaved.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_InjectedConversion_Interrupt/EWARM/ADC_InjectedConversion_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_DMA/EWARM/ADC_RegularConversion_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_Interrupt/EWARM/ADC_RegularConversion_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_Polling/EWARM/ADC_RegularConversion_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_TemperatureSensor/EWARM/ADC_TemperatureSensor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_TriggerMode/EWARM/ADC_TriggerMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_TripleModeInterleaved/EWARM/ADC_TripleModeInterleaved.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_DualModeInterleaved</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>ADC_InjectedConversion_Interrupt</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>ADC_RegularConversion_DMA</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>ADC_RegularConversion_Interrupt</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>ADC_RegularConversion_Polling</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>ADC_TemperatureSensor</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>ADC_TriggerMode</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>ADC_TripleModeInterleaved</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
