<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DMA2D_BlendingWithAlphaInversion/EWARM/DMA2D_BlendingWithAlphaInversion.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA2D_MemoryToMemory/EWARM/DMA2D_MemoryToMemory.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA2D_MemToMemWithBlending/EWARM/DMA2D_MemToMemWithBlending.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA2D_MemToMemWithBlendingAndCLUT/EWARM/DMA2D_MemToMemWithBlendingAndCLUT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA2D_MemToMemWithLCD/EWARM/DMA2D_MemToMemWithLCD.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA2D_MemToMemWithPFCandRedBlueSwap/EWARM/DMA2D_MemToMemWithPFCandRedBlueSwap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA2D_MemToMemWithPFC_A8/EWARM/DMA2D_MemToMemWithPFC_A8.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA2D_RegToMemWithLCD/EWARM/DMA2D_RegToMemWithLCD.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>DMA2D_BlendingWithAlphaInversion</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>DMA2D_MemoryToMemory</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>DMA2D_MemToMemWithBlending</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>DMA2D_MemToMemWithBlendingAndCLUT</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>DMA2D_MemToMemWithLCD</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>DMA2D_MemToMemWithPFCandRedBlueSwap</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>DMA2D_MemToMemWithPFC_A8</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
      <member>
        <project>DMA2D_RegToMemWithLCD</project>
        <configuration>STM32F769I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
