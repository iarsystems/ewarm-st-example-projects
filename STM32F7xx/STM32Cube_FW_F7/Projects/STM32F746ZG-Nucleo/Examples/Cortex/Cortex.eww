<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CORTEXM_MPU/EWARM/CORTEXM_MPU.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CORTEXM_SysTick/EWARM/CORTEXM_SysTick.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CORTEXM_MPU</project>
        <configuration>STM32746ZG_Nucleo</configuration>
      </member>
      <member>
        <project>CORTEXM_SysTick</project>
        <configuration>STM32746ZG_Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
