<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/UART_Printf/EWARM/UART_Printf.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>UART_Printf</project>
        <configuration>STM32746ZG_Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
