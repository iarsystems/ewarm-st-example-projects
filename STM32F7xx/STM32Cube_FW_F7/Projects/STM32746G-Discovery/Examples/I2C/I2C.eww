<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/I2C_TwoBoards_AdvComIT/EWARM/I2C_TwoBoards_AdvComIT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_TwoBoards_ComDMA/EWARM/I2C_TwoBoards_ComDMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_TwoBoards_ComIT/EWARM/I2C_TwoBoards_ComIT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_TwoBoards_ComPolling/EWARM/I2C_TwoBoards_ComPolling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>I2C_TwoBoards_AdvComIT</project>
        <configuration>STM32746G_DISCOVERY</configuration>
      </member>
      <member>
        <project>I2C_TwoBoards_ComDMA</project>
        <configuration>STM32746G_DISCOVERY</configuration>
      </member>
      <member>
        <project>I2C_TwoBoards_ComIT</project>
        <configuration>STM32746G_DISCOVERY</configuration>
      </member>
      <member>
        <project>I2C_TwoBoards_ComPolling</project>
        <configuration>STM32746G_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
