<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CEC_DataExchange/EWARM/CEC_DataExchange.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CEC_DataExchange</project>
        <configuration>STM32746G_DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
