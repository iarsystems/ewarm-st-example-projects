<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/QSPI_ExecuteInPlace/EWARM/QSPI_ExecuteInPlace.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/QSPI_PreInitConfig/EWARM/QSPI_PreInitConfig.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/QSPI_ReadWrite_IT/EWARM/QSPI_ReadWrite_IT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>QSPI_ExecuteInPlace</project>
        <configuration>STM32746G-DISCOVERY</configuration>
      </member>
      <member>
        <project>QSPI_PreInitConfig</project>
        <configuration>STM32746G-DISCOVERY</configuration>
      </member>
      <member>
        <project>QSPI_ReadWrite_IT</project>
        <configuration>STM32746G-DISCOVERY</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
