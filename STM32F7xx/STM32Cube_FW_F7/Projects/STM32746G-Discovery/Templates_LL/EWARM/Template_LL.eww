<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Template_LL.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>Template_LL</project>
        <configuration>STM32F746G_Discovery_AXIM_FLASH</configuration>
      </member>
      <member>
        <project>Template_LL</project>
        <configuration>STM32F746G_Discovery_ITCM_FLASH</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
