<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/COMP_AnalogWatchdog/EWARM/COMP_AnalogWatchdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/COMP_Interrupt/EWARM/COMP_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/COMP_PulseWidthMeasurement/EWARM/COMP_PulseWidthMeasurement.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/COMP_PWMSignalControl/EWARM/COMP_PWMSignalControl.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>COMP_AnalogWatchdog</project>
        <configuration>STM32L053R8_NUCLEO</configuration>
      </member>
      <member>
        <project>COMP_Interrupt</project>
        <configuration>STM32L053R8_NUCLEO</configuration>
      </member>
      <member>
        <project>COMP_PulseWidthMeasurement</project>
        <configuration>STM32L053R8_NUCLEO</configuration>
      </member>
      <member>
        <project>COMP_PWMSignalControl</project>
        <configuration>STM32L053R8_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
