<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/IWDG_Reset/EWARM/IWDG_Reset.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>IWDG_Reset</project>
        <configuration>STM32L031K6_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
