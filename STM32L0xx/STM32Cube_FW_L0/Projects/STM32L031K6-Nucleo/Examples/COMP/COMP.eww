<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/COMP_PWMSignalControl/EWARM/COMP_PWMSignalControl.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>COMP_PWMSignalControl</project>
        <configuration>STM32L031K6_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
