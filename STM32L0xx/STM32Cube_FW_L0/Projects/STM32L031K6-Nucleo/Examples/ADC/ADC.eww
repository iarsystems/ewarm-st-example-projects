<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_DMA_Transfer/EWARM/ADC_DMA_Transfer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_LowPower/EWARM/ADC_LowPower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_OverSampler/EWARM/ADC_OverSampler.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_Interrupt/EWARM/ADC_RegularConversion_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_Polling/EWARM/ADC_RegularConversion_Polling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_DMA_Transfer</project>
        <configuration>STM32L031K6_NUCLEO</configuration>
      </member>
      <member>
        <project>ADC_LowPower</project>
        <configuration>STM32L031K6_NUCLEO</configuration>
      </member>
      <member>
        <project>ADC_OverSampler</project>
        <configuration>STM32L031K6_NUCLEO</configuration>
      </member>
      <member>
        <project>ADC_RegularConversion_Interrupt</project>
        <configuration>STM32L031K6_NUCLEO</configuration>
      </member>
      <member>
        <project>ADC_RegularConversion_Polling</project>
        <configuration>STM32L031K6_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
