# IAR project CRYP_AESModes.ewp, settings and files
configuration STM32L031K6_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L041C6 ST STM32L041C6
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: STM32L041xx; USE_STM32L0XX_NUCLEO_32; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo_32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L031K6-Nucleo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l041xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt Expected_Results.txt
  group Example/User
    ../Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Example/EWARM
    ./: startup_stm32l041xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_cryp.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_dma.c
  group Drivers/BSP/STM32L0xx_Nucleo_32
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo_32/: stm32l0xx_nucleo_32.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
