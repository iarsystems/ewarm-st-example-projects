<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/GPIO_IOToggle/EWARM/GPIO_IOToggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/GPIO_IOToggle_MaxFrequency/EWARM/GPIO_IOToggle_MaxFrequency.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/GPIO_IOToggle_VariableFreq/EWARM/GPIO_IOToggle_VariableFreq.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>GPIO_IOToggle</project>
        <configuration>STM32L031K6_NUCLEO</configuration>
      </member>
      <member>
        <project>GPIO_IOToggle_MaxFrequency</project>
        <configuration>STM32L031K6_NUCLEO</configuration>
      </member>
      <member>
        <project>GPIO_IOToggle_VariableFreq</project>
        <configuration>STM32L031K6_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
