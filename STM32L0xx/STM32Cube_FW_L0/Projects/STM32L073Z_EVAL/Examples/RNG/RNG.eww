<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RNG_MultiRNG/EWARM/RNG_MultiRNG.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RNG_MultiRNG</project>
        <configuration>STM32L073Z_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
