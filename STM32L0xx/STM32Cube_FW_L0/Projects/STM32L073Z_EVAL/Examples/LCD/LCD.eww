<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/LCD_Blink_Frequency/EWARM/LCD_Blink_Frequency.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>LCD_Blink_Frequency</project>
        <configuration>STM32L073Z_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
