<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RCC_ClockConfig/EWARM/RCC_ClockConfig.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RCC_CRS_Synchronization_IT/EWARM/RCC_CRS_Synchronization_IT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RCC_CRS_Synchronization_Polling/EWARM/RCC_CRS_Synchronization_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RCC_LSIConfig/EWARM/RCC_LSIConfig.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RCC_ClockConfig</project>
        <configuration>STM32L073Z_EVAL</configuration>
      </member>
      <member>
        <project>RCC_CRS_Synchronization_IT</project>
        <configuration>STM32L073Z_EVAL</configuration>
      </member>
      <member>
        <project>RCC_CRS_Synchronization_Polling</project>
        <configuration>STM32L073Z_EVAL</configuration>
      </member>
      <member>
        <project>RCC_LSIConfig</project>
        <configuration>STM32L073Z_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
