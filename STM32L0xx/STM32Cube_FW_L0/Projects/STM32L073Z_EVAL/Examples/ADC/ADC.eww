<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_AnalogWatchdog/EWARM/ADC_AnalogWatchdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DMA_Transfer/EWARM/ADC_DMA_Transfer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_LowPower/EWARM/ADC_LowPower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_Interrupt/EWARM/ADC_RegularConversion_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_Polling/EWARM/ADC_RegularConversion_Polling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_AnalogWatchdog</project>
        <configuration>STM32L073Z_EVAL</configuration>
      </member>
      <member>
        <project>ADC_DMA_Transfer</project>
        <configuration>STM32L073Z_EVAL</configuration>
      </member>
      <member>
        <project>ADC_LowPower</project>
        <configuration>STM32L073Z_EVAL</configuration>
      </member>
      <member>
        <project>ADC_RegularConversion_Interrupt</project>
        <configuration>STM32L073Z_EVAL</configuration>
      </member>
      <member>
        <project>ADC_RegularConversion_Polling</project>
        <configuration>STM32L073Z_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
