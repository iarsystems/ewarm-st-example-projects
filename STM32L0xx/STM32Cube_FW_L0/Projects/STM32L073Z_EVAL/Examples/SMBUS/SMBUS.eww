<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SMBUS_TSENSOR/EWARM/SMBUS_TSENSOR.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SMBUS_TSENSOR</project>
        <configuration>STM32L073Z_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
