<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/PWR_LPRUN/EWARM/PWR_LPRUN.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_LPSLEEP/EWARM/PWR_LPSLEEP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_PVD/EWARM/PWR_PVD.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_SLEEP/EWARM/PWR_SLEEP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STANDBY/EWARM/PWR_STANDBY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STANDBY_RTC/EWARM/PWR_STANDBY_RTC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STOP/EWARM/PWR_STOP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STOP_RTC/EWARM/PWR_STOP_RTC.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>PWR_LPRUN</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
      <member>
        <project>PWR_LPSLEEP</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
      <member>
        <project>PWR_PVD</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
      <member>
        <project>PWR_SLEEP</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
      <member>
        <project>PWR_STANDBY</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
      <member>
        <project>PWR_STANDBY_RTC</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
      <member>
        <project>PWR_STOP</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
      <member>
        <project>PWR_STOP_RTC</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
