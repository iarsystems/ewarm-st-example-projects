<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/GPIO_EXTI/EWARM/GPIO_EXTI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/GPIO_IOToggle_MaxFrequency/EWARM/GPIO_IOToggle_MaxFrequency.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>GPIO_EXTI</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
      <member>
        <project>GPIO_IOToggle_MaxFrequency</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
