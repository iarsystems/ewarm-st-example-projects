<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DAC_SignalsGeneration/EWARM/DAC_SignalsGeneration.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DAC_SimpleConversion/EWARM/DAC_SimpleConversion.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>DAC_SignalsGeneration</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
      <member>
        <project>DAC_SimpleConversion</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
