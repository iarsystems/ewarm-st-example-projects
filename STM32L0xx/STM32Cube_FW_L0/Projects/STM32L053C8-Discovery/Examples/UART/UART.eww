<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/LPUART_TwoBoards_ComIT/EWARM/LPUART_TwoBoards_ComIT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LPUART_WakeUpFromStop/EWARM/LPUART_WakeUpFromStop.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_TwoBoards_ComDMA/EWARM/UART_TwoBoards_ComDMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_TwoBoards_ComIT/EWARM/UART_TwoBoards_ComIT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>LPUART_TwoBoards_ComIT</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
      <member>
        <project>LPUART_WakeUpFromStop</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
      <member>
        <project>UART_TwoBoards_ComDMA</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
      <member>
        <project>UART_TwoBoards_ComIT</project>
        <configuration>STM32L053C8_Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
