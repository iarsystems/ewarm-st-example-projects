<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RCC_LSIConfig/EWARM/RCC_LSIConfig.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RCC_LSIConfig</project>
        <configuration>STM32L011K4_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
