<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_DMA_Transfer/EWARM/ADC_DMA_Transfer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_LowPower/EWARM/ADC_LowPower.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_DMA_Transfer</project>
        <configuration>STM32L011K4_NUCLEO</configuration>
      </member>
      <member>
        <project>ADC_LowPower</project>
        <configuration>STM32L011K4_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
