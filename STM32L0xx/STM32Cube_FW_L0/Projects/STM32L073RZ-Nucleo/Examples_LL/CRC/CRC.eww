<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CRC_CalculateAndCheck/EWARM/CRC_CalculateAndCheck.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRC_UserDefinedPolynomial/EWARM/CRC_UserDefinedPolynomial.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CRC_CalculateAndCheck</project>
        <configuration>STM32L073RZ_NUCLEO</configuration>
      </member>
      <member>
        <project>CRC_UserDefinedPolynomial</project>
        <configuration>STM32L073RZ_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
