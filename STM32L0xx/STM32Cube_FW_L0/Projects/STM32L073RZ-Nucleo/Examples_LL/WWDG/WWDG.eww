<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/WWDG_RefreshUntilUserEvent/EWARM/WWDG_RefreshUntilUserEvent.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>WWDG_RefreshUntilUserEvent</project>
        <configuration>STM32L073RZ_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
