<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Lib_DEBUG_Example/Lib_DEBUG_Example.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Lib_DEBUG_Example</project>
        <configuration>STM32F051</configuration>
      </member>
      <member>
        <project>Lib_DEBUG_Example</project>
        <configuration>STM32F072</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
