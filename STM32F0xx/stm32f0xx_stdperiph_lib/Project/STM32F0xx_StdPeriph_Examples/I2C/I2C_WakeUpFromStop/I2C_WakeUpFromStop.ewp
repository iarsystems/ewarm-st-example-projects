# IAR project I2C_WakeUpFromStop.ewp, settings and files
configuration STM32F051 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051R8 ST STM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F051; USE_STM320518_EVAL; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM320518_EVAL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F0XX_MD.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/stm32f051_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F072 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F072VB ST STM32F072VB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F072; USE_STM32072B_EVAL; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM32072B_EVAL
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/stm32f072_flash.icf
  group CMSIS
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030.s startup_stm32f031.s startup_stm32f042.s startup_stm32f051.s startup_stm32f072.s
    ./: system_stm32f0xx.c
  group StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group STM320518_EVAL
    ../../../../Utilities/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c stm320518_eval_lcd.c
  group STM32072B_EVAL
    ../../../../Utilities/STM32_EVAL/STM32072B_EVAL/: stm32072b_eval.c stm32072b_eval_lcd.c
  group STM32F0xx_CPAL
    ../../../../Libraries/STM32F0xx_CPAL_Driver/src/: stm32f0xx_i2c_cpal.c stm32f0xx_i2c_cpal_hal.c
  group User
    ./: main.c stm32f0xx_i2c_cpal_conf.h stm32f0xx_i2c_cpal_usercallback.c stm32f0xx_it.c
