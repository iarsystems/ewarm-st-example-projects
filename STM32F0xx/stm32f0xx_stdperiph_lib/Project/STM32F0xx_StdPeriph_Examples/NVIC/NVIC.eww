<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/NVIC_WFI_Mode/NVIC_WFI_Mode.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>NVIC_WFI_Mode</project>
        <configuration>STM32F051</configuration>
      </member>
      <member>
        <project>NVIC_WFI_Mode</project>
        <configuration>STM32F072</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
