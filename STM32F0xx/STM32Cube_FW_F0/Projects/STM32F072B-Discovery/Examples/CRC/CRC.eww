<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CRC_Bytes_Stream_7bit_CRC/EWARM/CRC_Bytes_Stream_7bit_CRC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRC_Data_Reversing_16bit_CRC/EWARM/CRC_Data_Reversing_16bit_CRC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRC_Example/EWARM/CRC_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRC_UserDefinedPolynomial/EWARM/CRC_UserDefinedPolynomial.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CRC_Bytes_Stream_7bit_CRC</project>
        <configuration>STM32F072B-Discovery</configuration>
      </member>
      <member>
        <project>CRC_Data_Reversing_16bit_CRC</project>
        <configuration>STM32F072B-Discovery</configuration>
      </member>
      <member>
        <project>CRC_Example</project>
        <configuration>STM32F072B-Discovery</configuration>
      </member>
      <member>
        <project>CRC_UserDefinedPolynomial</project>
        <configuration>STM32F072B-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
