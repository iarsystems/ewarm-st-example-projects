<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_DMA_Transfer/EWARM/ADC_DMA_Transfer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_Polling/EWARM/ADC_RegularConversion_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_TriggerMode/EWARM/ADC_TriggerMode.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_DMA_Transfer</project>
        <configuration>STM32F072B-Discovery</configuration>
      </member>
      <member>
        <project>ADC_RegularConversion_Polling</project>
        <configuration>STM32F072B-Discovery</configuration>
      </member>
      <member>
        <project>ADC_TriggerMode</project>
        <configuration>STM32F072B-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
