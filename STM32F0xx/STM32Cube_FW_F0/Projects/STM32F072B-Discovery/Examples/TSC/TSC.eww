<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TSC_BasicAcquisition_Interrupt/EWARM/TSC_BasicAcquisition_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TSC_BasicAcquisition_Polling/EWARM/TSC_BasicAcquisition_Polling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TSC_BasicAcquisition_Interrupt</project>
        <configuration>STM32F072B-Discovery</configuration>
      </member>
      <member>
        <project>TSC_BasicAcquisition_Polling</project>
        <configuration>STM32F072B-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
