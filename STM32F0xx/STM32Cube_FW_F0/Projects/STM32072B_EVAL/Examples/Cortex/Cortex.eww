<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CORTEXM_SysTick/EWARM/CORTEXM_SysTick.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CORTEXM_SysTick</project>
        <configuration>STM32072B_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
