<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/IWDG_Reset/EWARM/IWDG_Reset.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/IWDG_WindowMode/EWARM/IWDG_WindowMode.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>IWDG_Reset</project>
        <configuration>STM32072B_EVAL</configuration>
      </member>
      <member>
        <project>IWDG_WindowMode</project>
        <configuration>STM32072B_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
