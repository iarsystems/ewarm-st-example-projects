<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SMBUS_TSENSOR/EWARM/SMBUS_TSENSOR.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SMBUS_TSENSOR</project>
        <configuration>STM32072B_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
