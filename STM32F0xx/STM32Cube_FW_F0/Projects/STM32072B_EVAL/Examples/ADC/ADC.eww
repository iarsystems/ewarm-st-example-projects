<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_DMA_Transfer/EWARM/ADC_DMA_Transfer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_LowPower/EWARM/ADC_LowPower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_Polling/EWARM/ADC_RegularConversion_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_TriggerMode/EWARM/ADC_TriggerMode.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_DMA_Transfer</project>
        <configuration>STM32072B_EVAL</configuration>
      </member>
      <member>
        <project>ADC_LowPower</project>
        <configuration>STM32072B_EVAL</configuration>
      </member>
      <member>
        <project>ADC_RegularConversion_Polling</project>
        <configuration>STM32072B_EVAL</configuration>
      </member>
      <member>
        <project>ADC_TriggerMode</project>
        <configuration>STM32072B_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
