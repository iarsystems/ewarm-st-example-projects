<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/PWR_STANDBY_RTC/EWARM/PWR_STANDBY_RTC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STOP/EWARM/PWR_STOP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>PWR_STANDBY_RTC</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
      <member>
        <project>PWR_STOP</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
