<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/USART_Communication_Rx_IT/EWARM/USART_Communication_Rx_IT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_Communication_Rx_IT_Continuous/EWARM/USART_Communication_Rx_IT_Continuous.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_Communication_Rx_IT_Init/EWARM/USART_Communication_Rx_IT_Init.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_Communication_Tx/EWARM/USART_Communication_Tx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_Communication_TxRx_DMA/EWARM/USART_Communication_TxRx_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_Communication_Tx_IT/EWARM/USART_Communication_Tx_IT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_HardwareFlowControl/EWARM/USART_HardwareFlowControl.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_SyncCommunication_FullDuplex_DMA/EWARM/USART_SyncCommunication_FullDuplex_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_SyncCommunication_FullDuplex_IT/EWARM/USART_SyncCommunication_FullDuplex_IT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_WakeUpFromStop/EWARM/USART_WakeUpFromStop.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>USART_Communication_Rx_IT</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
      <member>
        <project>USART_Communication_Rx_IT_Continuous</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
      <member>
        <project>USART_Communication_Rx_IT_Init</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
      <member>
        <project>USART_Communication_Tx</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
      <member>
        <project>USART_Communication_TxRx_DMA</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
      <member>
        <project>USART_Communication_Tx_IT</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
      <member>
        <project>USART_HardwareFlowControl</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
      <member>
        <project>USART_SyncCommunication_FullDuplex_DMA</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
      <member>
        <project>USART_SyncCommunication_FullDuplex_IT</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
      <member>
        <project>USART_WakeUpFromStop</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
