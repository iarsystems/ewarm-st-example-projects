<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CRS_Synchronization_IT/EWARM/CRS_Synchronization_IT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRS_Synchronization_Polling/EWARM/CRS_Synchronization_Polling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CRS_Synchronization_IT</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
      <member>
        <project>CRS_Synchronization_Polling</project>
        <configuration>STM32F072RB-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
