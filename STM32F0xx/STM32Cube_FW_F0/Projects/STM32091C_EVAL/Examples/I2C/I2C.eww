<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/I2C_EEPROM/EWARM/I2C_EEPROM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_TwoBoards_AdvComIT/EWARM/I2C_TwoBoards_AdvComIT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_WakeUpFromStop/EWARM/I2C_WakeUpFromStop.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>I2C_EEPROM</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
      <member>
        <project>I2C_TwoBoards_AdvComIT</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
      <member>
        <project>I2C_WakeUpFromStop</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
