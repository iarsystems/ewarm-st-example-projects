<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/UART_HyperTerminal_DMA/EWARM/UART_HyperTerminal_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_OneBoards_8UART/EWARM/UART_OneBoards_8UART.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_WakeUpFromStop/EWARM/UART_WakeUpFromStop.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>UART_HyperTerminal_DMA</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
      <member>
        <project>UART_OneBoards_8UART</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
      <member>
        <project>UART_WakeUpFromStop</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
