<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CRC_Example/EWARM/CRC_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRC_UserDefinedPolynomial/EWARM/CRC_UserDefinedPolynomial.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CRC_Example</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
      <member>
        <project>CRC_UserDefinedPolynomial</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
