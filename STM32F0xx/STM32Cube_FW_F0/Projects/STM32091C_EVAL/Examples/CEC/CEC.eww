<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CEC_DataExchange/EWARM/CEC_DataExchange.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CEC_ListenMode/EWARM/CEC_ListenMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CEC_MultiAddress/EWARM/CEC_MultiAddress.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CEC_DataExchange</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
      <member>
        <project>CEC_ListenMode</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
      <member>
        <project>CEC_MultiAddress</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
