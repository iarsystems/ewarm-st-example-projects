<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TIM_InputCapture/EWARM/TIM_InputCapture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PWMOutput/EWARM/TIM_PWMOutput.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TIM_InputCapture</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
      <member>
        <project>TIM_PWMOutput</project>
        <configuration>STM32091C_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
