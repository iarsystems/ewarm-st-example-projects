<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/WWDG_Example/EWARM/WWDG_Example.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>WWDG_Example</project>
        <configuration>STM32F031K6_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
