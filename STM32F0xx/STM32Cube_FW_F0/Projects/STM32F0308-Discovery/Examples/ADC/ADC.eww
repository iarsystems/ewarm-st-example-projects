<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_DMA_Transfer/EWARM/ADC_DMA_Transfer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_DMA_Transfer</project>
        <configuration>STM32F0308-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
