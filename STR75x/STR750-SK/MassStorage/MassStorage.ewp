# IAR project MassStorage.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR750FV2 ST STR750FV2
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: MMC_DISK_INFO
  ICCARM.CCIncludePath2: ; app\; board\; module\; ..\..\STR75xLibrary\library\inc\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MassStorage.out
  ILINK.IlinkIcfFile: config/STR75x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug KS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: MMC_DISK_INFO; DEBUG_KS
  ICCARM.CCOptLevel: 1
  group (top)
    app/: 75x_conf.h 75x_it.c main.c
  group Common
    app/: 75x_init.s 75x_vect.s
  group Luns
    app/: lun.c mmc.c mmc_dsk_desc.c
  group Module
    module/: drv_hd44780.c drv_hd44780_l.c STR75x_USB.c
  group SCSI
    app/: scsi.c
  group STR75x_lib
    ../../STR75xLibrary/library/src/: 75x_cfg.c 75x_eic.c 75x_gpio.c 75x_lib.c 75x_mrcc.c 75x_rtc.c 75x_ssp.c 75x_tim.c
  group USB
    app/: usb_dev_desc.c
