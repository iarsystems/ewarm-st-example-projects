<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/MassStorage.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>MassStorage</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MassStorage</project>
        <configuration>Debug KS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
