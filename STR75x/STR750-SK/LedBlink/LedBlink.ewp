# IAR project LedBlink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR750FV2 ST STR750FV2
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; ..\..\STR75xLibrary\library\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: LedBlink.out
  ILINK.IlinkIcfFile: config/STR75x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 75x_conf.h 75x_it.c main.c
  group Startup
    ./: 75x_init.s 75x_vect.s
  group STR75x_lib
    ../../STR75xLibrary/library/src/: 75x_cfg.c 75x_eic.c 75x_gpio.c 75x_lib.c 75x_mrcc.c 75x_tim.c
