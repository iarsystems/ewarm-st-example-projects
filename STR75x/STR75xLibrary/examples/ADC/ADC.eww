<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Example1/ADC_Example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example2/ADC_Example2.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>ADC_Example1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ADC_Example2</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
