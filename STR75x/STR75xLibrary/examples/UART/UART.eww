<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Example1/UART_Example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example2/UART_Example2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example3/UART_Example3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example4/UART_Example4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example5/UART_Example5.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example6/UART_Example6.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>UART_Example1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_Example2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_Example3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_Example4</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_Example5</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART_Example6</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
