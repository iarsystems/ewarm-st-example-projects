<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Example1_OC/OCActive_Mode/TIM_OCActive_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example1_OC/OCTiming_Mode/TIM_OCTiming_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example1_OC/PWM_Mode/TIM_PWM_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example1_OC/Toggle_Mode/TIM_Toggle_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example2_PWMI/TIM_Example2_PWMI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example3_OPM/OPM_PWM_Mode/TIM_OPM_PWM_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example3_OPM/OPM_Toggle_Mode/TIM_OPM_Toggle_Mode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example4_Sync_Parallel/TIM_Example4_Sync_Parellel.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example5_DMA/TIM_Example5_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example6_Syn_Cascade/TIM_Example6_Syn_Cascade.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Example7_Encoder/TIM_Example7_Encoder.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>TIM_Example2_PWMI</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_Example4_Sync_Parellel</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_Example5_DMA</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_Example6_Syn_Cascade</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_Example7_Encoder</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_OCActive_Mode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_OCTiming_Mode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_OPM_PWM_Mode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_OPM_Toggle_Mode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_PWM_Mode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIM_Toggle_Mode</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
