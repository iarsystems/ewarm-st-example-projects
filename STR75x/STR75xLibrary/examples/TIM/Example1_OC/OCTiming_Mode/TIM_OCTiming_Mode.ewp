# IAR project TIM_OCTiming_Mode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR750FV2 ST STR750FV2
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCIncludePath2: ; ..\..\..\..\library\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: TIM_OCTiming_Mode.out
  ILINK.IlinkIcfFile: ../../../../linker/STR75x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 75x_it.c main.c
  group source
    ../../../../library/src/: 75x_cfg.c 75x_eic.c 75x_gpio.c 75x_lib.c 75x_mrcc.c 75x_tim.c
  group startup
    ../../../../startup/: 75x_init.s 75x_vect.s
