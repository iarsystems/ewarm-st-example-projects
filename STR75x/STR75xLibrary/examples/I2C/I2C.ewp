# IAR project I2C.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR750FV2 ST STR750FV2
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCIncludePath2: ; ..\..\library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: I2C.out
  ILINK.IlinkIcfFile: ../../linker/STR75x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 75x_it.c i2c_ee.c main.c
  group source
    ../../library/src/: 75x_gpio.c 75x_i2c.c 75x_lib.c 75x_mrcc.c
  group startup
    ../../startup/: 75x_init.s 75x_vect.s
