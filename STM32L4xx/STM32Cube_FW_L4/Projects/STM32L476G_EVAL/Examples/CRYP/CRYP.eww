<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CRYP_AESModes/EWARM/CRYP_AESModes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_AESModes_Suspension/EWARM/CRYP_AESModes_Suspension.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_DMA/EWARM/CRYP_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_GCM_GMAC_CMAC_Modes/EWARM/CRYP_GCM_GMAC_CMAC_Modes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_GCM_GMAC_CMAC_Suspension/EWARM/CRYP_GCM_GMAC_CMAC_Suspension.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CRYP_AESModes</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AESModes_Suspension</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_DMA</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_GCM_GMAC_CMAC_Modes</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_GCM_GMAC_CMAC_Suspension</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
