<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SAI_AudioPlay/EWARM/SAI_AudioPlay.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SAI_AudioPlay</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
