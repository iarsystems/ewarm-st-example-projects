<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_AnalogWatchdog/EWARM/ADC_AnalogWatchdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DMA_Transfer/EWARM/ADC_DMA_Transfer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DualModeInterleaved/EWARM/ADC_DualModeInterleaved.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_OverSampler/EWARM/ADC_OverSampler.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_Polling/EWARM/ADC_RegularConversion_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_Regular_injected_groups/EWARM/ADC_Regular_injected_groups.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_Sequencer/EWARM/ADC_Sequencer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_AnalogWatchdog</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
      <member>
        <project>ADC_DMA_Transfer</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
      <member>
        <project>ADC_DualModeInterleaved</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
      <member>
        <project>ADC_OverSampler</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
      <member>
        <project>ADC_RegularConversion_Polling</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
      <member>
        <project>ADC_Regular_injected_groups</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
      <member>
        <project>ADC_Sequencer</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
