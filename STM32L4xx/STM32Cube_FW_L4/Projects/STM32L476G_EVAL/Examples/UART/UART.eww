<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/UART_HyperTerminal_DMA/EWARM/UART_HyperTerminal_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_Printf/EWARM/UART_Printf.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>UART_HyperTerminal_DMA</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
      <member>
        <project>UART_Printf</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
