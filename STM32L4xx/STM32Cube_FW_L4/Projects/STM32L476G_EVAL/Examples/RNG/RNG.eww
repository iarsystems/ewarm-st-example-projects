<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RNG_MultiRNG/EWARM/RNG_MultiRNG.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RNG_MultiRNG_IT/EWARM/RNG_MultiRNG_IT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RNG_MultiRNG</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
      <member>
        <project>RNG_MultiRNG_IT</project>
        <configuration>STM32L476G_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
