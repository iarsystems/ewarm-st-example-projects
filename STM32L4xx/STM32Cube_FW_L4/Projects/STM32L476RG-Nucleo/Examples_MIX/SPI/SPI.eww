<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SPI_FullDuplex_ComPolling/EWARM/SPI_FullDuplex_ComPolling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SPI_HalfDuplex_ComPollingIT/EWARM/SPI_HalfDuplex_ComPollingIT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SPI_FullDuplex_ComPolling</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>SPI_HalfDuplex_ComPollingIT</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
