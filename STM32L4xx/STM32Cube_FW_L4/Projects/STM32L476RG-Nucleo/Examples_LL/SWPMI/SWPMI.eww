<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SWPMI_Loopback_MultiSWBuffer/EWARM/SWPMI_Loopback_MultiSWBuffer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SWPMI_Loopback_MultiSWBuffer_Init/EWARM/SWPMI_Loopback_MultiSWBuffer_Init.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SWPMI_Loopback_NoSWBuffer/EWARM/SWPMI_Loopback_NoSWBuffer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SWPMI_Loopback_MultiSWBuffer</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>SWPMI_Loopback_MultiSWBuffer_Init</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>SWPMI_Loopback_NoSWBuffer</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
