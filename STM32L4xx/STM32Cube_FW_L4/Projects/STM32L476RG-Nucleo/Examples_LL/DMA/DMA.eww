<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DMA_CopyFromFlashToMemory/EWARM/DMA_CopyFromFlashToMemory.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA_CopyFromFlashToMemory_Init/EWARM/DMA_CopyFromFlashToMemory_Init.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>DMA_CopyFromFlashToMemory</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>DMA_CopyFromFlashToMemory_Init</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
