<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/PWR_LPRUN/EWARM/PWR_LPRUN.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_LPRUN_SRAM1/EWARM/PWR_LPRUN_SRAM1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_LPSLEEP/EWARM/PWR_LPSLEEP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_ModesSelection/EWARM/PWR_ModesSelection.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_SHUTDOWN/EWARM/PWR_SHUTDOWN.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_SLEEP/EWARM/PWR_SLEEP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STANDBY/EWARM/PWR_STANDBY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STANDBY_RTC/EWARM/PWR_STANDBY_RTC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STOP1/EWARM/PWR_STOP1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STOP1_RTC/EWARM/PWR_STOP1_RTC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STOP2/EWARM/PWR_STOP2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STOP2_RTC/EWARM/PWR_STOP2_RTC.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>PWR_LPRUN</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>PWR_LPRUN_SRAM1</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>PWR_LPSLEEP</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>PWR_ModesSelection</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>PWR_SHUTDOWN</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>PWR_SLEEP</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>PWR_STANDBY</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>PWR_STANDBY_RTC</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>PWR_STOP1</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>PWR_STOP1_RTC</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>PWR_STOP2</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>PWR_STOP2_RTC</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
