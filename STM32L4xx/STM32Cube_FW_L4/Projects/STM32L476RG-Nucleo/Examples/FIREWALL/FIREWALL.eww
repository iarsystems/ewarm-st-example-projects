<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/FIREWALL_VolatileData_Executable/EWARM/FIREWALL_VolatileData_Executable.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FIREWALL_VolatileData_Shared/EWARM/FIREWALL_VolatileData_Shared.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>FIREWALL_VolatileData_Executable</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
      <member>
        <project>FIREWALL_VolatileData_Shared</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
