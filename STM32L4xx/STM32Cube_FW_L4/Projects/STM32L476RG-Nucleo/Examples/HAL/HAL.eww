<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/HAL_TimeBase/EWARM/HAL_TimeBase.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>HAL_TimeBase</project>
        <configuration>STM32L476RG_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
