# IAR project MP3_Player.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; app\; board\; modules\; efsl\inc\; efsl\interfaces\; ..\library\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\library\STM32F10x_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MP3_Player.out
  ILINK.IlinkIcfFile: config/STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: keys.c main.c stm32f10x_conf.h
  group CMSIS
    ../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group efs
    efsl/src/: debug.c dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ioman_v2.c ls.c mkfs.c partition.c plibc.c regressiontest.c time.c ui.c
  group efs/Interfaces
    efsl/interfaces/: arm_spi.c
  group efs/Interfaces/SD/MMC
    modules/: sd_ll_spi2.c sd_ll_spi2_cfg.h sd_spi_mode.c
  group HD44780
    modules/: drv_hd44780.c drv_hd44780_cnfg.h drv_hd44780_l.c
  group Others
    ./: readme.txt
    config/: STM32F10x_FLASH.icf
  group StdPeriph_Driver
    ../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Vectors
    app/: stm32f10x_it.c
  group VS1002
    modules/: drv_vs1002.c drv_vs1002_cnfg.h
