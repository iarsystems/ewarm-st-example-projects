# IAR project Flash_Loader.ewp, settings and files
configuration STM3210C-EVAL_FW (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flash_Loader.srec
  ILINK.IlinkOutputFile: Flash_Loader.out
  ILINK.IlinkKeepSymbols: DEMO
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
