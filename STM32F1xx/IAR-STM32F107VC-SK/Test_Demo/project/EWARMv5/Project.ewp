# IAR project Project.ewp, settings and files
configuration STM32F107VCT6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\..\..\library\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\library\STM32F10x_StdPeriph_Driver\inc; ..\..\..\library\STM32_ETH_Driver\inc; ..\..\Drivers; ..\..\Drivers\uIP
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../../../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Drivers/Accelerometer
    ../../Drivers/: accl_drv.c
  group Drivers/Font
    ../../Drivers/: iar_logo.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group Drivers/FSMC
    ../../Drivers/: fsmc_sram.c
  group Drivers/GLCD
    ../../Drivers/: drv_glcd.c glcd_ll.c
  group Drivers/I2C
    ../../Drivers/: i2c1_drv.c
  group Drivers/Step_Motor
    ../../Drivers/: step_motor_drv.c
  group Drivers/Temp.Sensor
    ../../Drivers/: temp_sensor_drv.c
  group Drivers/uIP
    ../../Drivers/uip/: cgi.c fs.c httpd.c uip.c uip_arch.c uip_arp.c uIPMain.c
  group StdPeriph_Driver
    ../../../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_ETH_Driver
    ../../../library/STM32_ETH_Driver/src/: stm32_eth.c
  group Test
    ../../Test/: Accelerometer_Test.c Button_Test.c Buzzer_Test.c CAN_Test.c Ethernet_Test.c LED_Test.c Potentiometer_Test.c Sounds.c Stepper_Motor_Test.c Temp_Sensor_Test.c USART1_Test.c USART2_Test.c
  group User
    ../: main.c menu.c stm32f10x_conf.h stm32f10x_it.c
