<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DualModeDMA_SineWave/DualModeDMA_SineWave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OneChannel_NoiseWave/OneChannel_NoiseWave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OneChannelDMA_Escalator/OneChannelDMA_Escalator.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TwoChannels_TriangleWave/TwoChannels_TriangleWave.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>DualModeDMA_SineWave</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>DualModeDMA_SineWave</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>DualModeDMA_SineWave</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>DualModeDMA_SineWave</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>DualModeDMA_SineWave</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>DualModeDMA_SineWave</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>OneChannel_NoiseWave</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>OneChannel_NoiseWave</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>OneChannel_NoiseWave</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>OneChannel_NoiseWave</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>OneChannel_NoiseWave</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>OneChannel_NoiseWave</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>OneChannelDMA_Escalator</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>OneChannelDMA_Escalator</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>OneChannelDMA_Escalator</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>OneChannelDMA_Escalator</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>OneChannelDMA_Escalator</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>OneChannelDMA_Escalator</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>TwoChannels_TriangleWave</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>TwoChannels_TriangleWave</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>TwoChannels_TriangleWave</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>TwoChannels_TriangleWave</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>TwoChannels_TriangleWave</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>TwoChannels_TriangleWave</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
