<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DualCAN/DualCAN.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LoopBack/LoopBack.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Networking/Networking.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Normal/Normal.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>DualCAN</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>LoopBack</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>LoopBack</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>LoopBack</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>LoopBack</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>LoopBack</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>LoopBack</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Networking</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Networking</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Networking</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Networking</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Networking</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Networking</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Normal</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Normal</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Normal</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Normal</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Normal</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Normal</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
