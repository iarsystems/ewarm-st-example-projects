<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Calendar/Calendar.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LSI_Calib/LSI_Calib.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Calendar</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Calendar</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Calendar</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Calendar</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Calendar</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Calendar</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>LSI_Calib</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>LSI_Calib</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>LSI_Calib</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>LSI_Calib</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>LSI_Calib</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>LSI_Calib</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
