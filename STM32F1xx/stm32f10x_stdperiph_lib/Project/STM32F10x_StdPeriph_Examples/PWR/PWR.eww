<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/PVD/PVD.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/STANDBY/STANDBY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/STOP/STOP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>PVD</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>PVD</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>PVD</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>PVD</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>PVD</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>PVD</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>STANDBY</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>STANDBY</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>STANDBY</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>STANDBY</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>STANDBY</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>STANDBY</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>STOP</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>STOP</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>STOP</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>STOP</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>STOP</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>STOP</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
