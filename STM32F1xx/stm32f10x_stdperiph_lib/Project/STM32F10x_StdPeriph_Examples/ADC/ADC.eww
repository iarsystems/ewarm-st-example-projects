<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/3ADCs_DMA/3ADCs_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC1_DMA/ADC1_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/AnalogWatchdog/AnalogWatchdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ExtLinesTrigger/ExtLinesTrigger.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RegSimul_DualMode/RegSimul_DualMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIMTrigger_AutoInjection/TIMTrigger_AutoInjection.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>3ADCs_DMA</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>3ADCs_DMA</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>3ADCs_DMA</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>3ADCs_DMA</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>3ADCs_DMA</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>3ADCs_DMA</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>ADC1_DMA</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>ADC1_DMA</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>ADC1_DMA</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>ADC1_DMA</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>ADC1_DMA</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>ADC1_DMA</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>AnalogWatchdog</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>AnalogWatchdog</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>AnalogWatchdog</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>AnalogWatchdog</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>AnalogWatchdog</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>AnalogWatchdog</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>ExtLinesTrigger</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>ExtLinesTrigger</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>ExtLinesTrigger</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>ExtLinesTrigger</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>ExtLinesTrigger</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>ExtLinesTrigger</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>RegSimul_DualMode</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>RegSimul_DualMode</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>RegSimul_DualMode</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>RegSimul_DualMode</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>RegSimul_DualMode</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>RegSimul_DualMode</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>TIMTrigger_AutoInjection</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>TIMTrigger_AutoInjection</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>TIMTrigger_AutoInjection</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>TIMTrigger_AutoInjection</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>TIMTrigger_AutoInjection</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>TIMTrigger_AutoInjection</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
