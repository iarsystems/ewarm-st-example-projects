<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CRC/CRC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA/DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FullDuplex_SoftNSS/FullDuplex_SoftNSS.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Simplex_Interrupt/Simplex_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SPI_FLASH/SPI_FLASH.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>CRC</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>CRC</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>CRC</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>CRC</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>CRC</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>CRC</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>FullDuplex_SoftNSS</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>FullDuplex_SoftNSS</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>FullDuplex_SoftNSS</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>FullDuplex_SoftNSS</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>FullDuplex_SoftNSS</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>FullDuplex_SoftNSS</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Simplex_Interrupt</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Simplex_Interrupt</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Simplex_Interrupt</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Simplex_Interrupt</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Simplex_Interrupt</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Simplex_Interrupt</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>SPI_FLASH</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>SPI_FLASH</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>SPI_FLASH</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>SPI_FLASH</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>SPI_FLASH</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>SPI_FLASH</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
