<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Interrupt/Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SPI_I2S_Switch/SPI_I2S_Switch.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Interrupt</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Interrupt</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>SPI_I2S_Switch</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>SPI_I2S_Switch</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
