<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/BitBand/BitBand.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Mode_Privilege/Mode_Privilege.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/MPU/MPU.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>BitBand</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>BitBand</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>BitBand</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>BitBand</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>BitBand</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>BitBand</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Mode_Privilege</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Mode_Privilege</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Mode_Privilege</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Mode_Privilege</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Mode_Privilege</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Mode_Privilege</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>MPU</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>MPU</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>MPU</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>MPU</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>MPU</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>MPU</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
