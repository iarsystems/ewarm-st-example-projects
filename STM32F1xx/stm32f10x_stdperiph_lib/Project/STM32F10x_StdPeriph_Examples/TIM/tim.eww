<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/6Steps/6Steps.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/7PWM_Output/7PWM_Output.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Cascade_Synchro/Cascade_Synchro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ComplementarySignals/ComplementarySignals.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA/DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMABurst/DMABurst.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ExtTrigger_Synchro/ExtTrigger_Synchro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/InputCapture/InputCapture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OCActive/OCActive.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OCInactive/OCInactive.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OCToggle/OCToggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OnePulse/OnePulse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Parallel_Synchro/Parallel_Synchro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWM_Input/PWM_Input.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWM_Output/PWM_Output.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM10_PWMOutput/TIM10_PWMOutput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM15_ComplementarySignals/TIM15_ComplementarySignals.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM1_Synchro/TIM1_Synchro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM9_OCToggle/TIM9_OCToggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TimeBase/TimeBase.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>6Steps</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>6Steps</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>6Steps</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>6Steps</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>6Steps</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>6Steps</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>7PWM_Output</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>7PWM_Output</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>7PWM_Output</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>7PWM_Output</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>7PWM_Output</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>7PWM_Output</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Cascade_Synchro</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Cascade_Synchro</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Cascade_Synchro</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Cascade_Synchro</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Cascade_Synchro</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Cascade_Synchro</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>ComplementarySignals</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>ComplementarySignals</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>ComplementarySignals</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>ComplementarySignals</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>ComplementarySignals</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>ComplementarySignals</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>DMA</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>DMABurst</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>DMABurst</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>DMABurst</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>DMABurst</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>DMABurst</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>DMABurst</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>ExtTrigger_Synchro</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>ExtTrigger_Synchro</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>ExtTrigger_Synchro</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>ExtTrigger_Synchro</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>ExtTrigger_Synchro</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>ExtTrigger_Synchro</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>InputCapture</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>InputCapture</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>InputCapture</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>InputCapture</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>InputCapture</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>InputCapture</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>OCActive</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>OCActive</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>OCActive</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>OCActive</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>OCActive</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>OCActive</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>OCInactive</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>OCInactive</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>OCInactive</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>OCInactive</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>OCInactive</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>OCInactive</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>OCToggle</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>OCToggle</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>OCToggle</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>OCToggle</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>OCToggle</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>OCToggle</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>OnePulse</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>OnePulse</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>OnePulse</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>OnePulse</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>OnePulse</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>OnePulse</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Parallel_Synchro</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Parallel_Synchro</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Parallel_Synchro</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Parallel_Synchro</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Parallel_Synchro</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Parallel_Synchro</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>PWM_Input</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>PWM_Input</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>PWM_Input</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>PWM_Input</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>PWM_Input</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>PWM_Input</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>PWM_Output</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>PWM_Output</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>PWM_Output</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>PWM_Output</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>PWM_Output</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>PWM_Output</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>TIM1_Synchro</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>TIM1_Synchro</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>TIM1_Synchro</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>TIM1_Synchro</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>TIM1_Synchro</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>TIM1_Synchro</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>TIM10_PWMOutput</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>TIM10_PWMOutput</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>TIM10_PWMOutput</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>TIM10_PWMOutput</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>TIM10_PWMOutput</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>TIM10_PWMOutput</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>TIM15_ComplementarySignals</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>TIM15_ComplementarySignals</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>TIM15_ComplementarySignals</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>TIM15_ComplementarySignals</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>TIM15_ComplementarySignals</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>TIM15_ComplementarySignals</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>TIM9_OCToggle</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>TIM9_OCToggle</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>TIM9_OCToggle</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>TIM9_OCToggle</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>TIM9_OCToggle</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>TIM9_OCToggle</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>TimeBase</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>TimeBase</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>TimeBase</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>TimeBase</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>TimeBase</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>TimeBase</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
