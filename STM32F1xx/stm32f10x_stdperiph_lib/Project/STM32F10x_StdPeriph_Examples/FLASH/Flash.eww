<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Dual_Boot/Dual_Boot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Program/Program.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Write_Protection/Write_Protection.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Dual_Boot</project>
        <configuration>STM32F10X_XL_BANK1</configuration>
      </member>
      <member>
        <project>Dual_Boot</project>
        <configuration>STM32F10X_XL_BANK2</configuration>
      </member>
      <member>
        <project>Program</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Program</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Program</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Program</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Program</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Program</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Write_Protection</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Write_Protection</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Write_Protection</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Write_Protection</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Write_Protection</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Write_Protection</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
