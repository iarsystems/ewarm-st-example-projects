<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/EEPROM/EEPROM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_TSENSOR/I2C_TSENSOR.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/IOExpander/IOExpander.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>EEPROM</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>EEPROM</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>EEPROM</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>EEPROM</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>EEPROM</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>EEPROM</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>I2C_TSENSOR</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>I2C_TSENSOR</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>I2C_TSENSOR</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>I2C_TSENSOR</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>I2C_TSENSOR</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>I2C_TSENSOR</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>IOExpander</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>IOExpander</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>IOExpander</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>IOExpander</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>IOExpander</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>IOExpander</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
