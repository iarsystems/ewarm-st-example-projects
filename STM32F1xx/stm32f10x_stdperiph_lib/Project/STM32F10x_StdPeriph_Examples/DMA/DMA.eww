<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_TIM1/ADC_TIM1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FLASH_RAM/FLASH_RAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FSMC/FSMC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_RAM/I2C_RAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SPI_RAM/SPI_RAM.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>ADC_TIM1</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>ADC_TIM1</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>ADC_TIM1</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>ADC_TIM1</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>ADC_TIM1</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>ADC_TIM1</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>FLASH_RAM</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>FLASH_RAM</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>FLASH_RAM</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>FLASH_RAM</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>FLASH_RAM</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>FLASH_RAM</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>FSMC</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>FSMC</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>FSMC</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>FSMC</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>FSMC</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>FSMC</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>I2C_RAM</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>I2C_RAM</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>I2C_RAM</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>I2C_RAM</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>I2C_RAM</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>I2C_RAM</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>SPI_RAM</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>SPI_RAM</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>SPI_RAM</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>SPI_RAM</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>SPI_RAM</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>SPI_RAM</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
