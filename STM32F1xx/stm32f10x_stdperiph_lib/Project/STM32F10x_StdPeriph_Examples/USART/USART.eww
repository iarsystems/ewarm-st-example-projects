<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DMA_Interrupt/DMA_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA_Polling/DMA_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HalfDuplex/HalfDuplex.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HyperTerminal_HwFlowControl/HyperTerminal_HwFlowControl.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HyperTerminal_Interrupt/HyperTerminal_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Interrupt/Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/MultiProcessor/MultiProcessor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Polling/Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Printf/Printf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/IrDA/Receive/Receive.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Smartcard/Smartcard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Synchronous/Synchronous.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/IrDA/Transmit/Transmit.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>DMA_Interrupt</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>DMA_Interrupt</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>DMA_Interrupt</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>DMA_Interrupt</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>DMA_Interrupt</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>DMA_Interrupt</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>DMA_Polling</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>DMA_Polling</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>DMA_Polling</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>DMA_Polling</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>DMA_Polling</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>DMA_Polling</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>HalfDuplex</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>HalfDuplex</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>HalfDuplex</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>HalfDuplex</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>HalfDuplex</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>HalfDuplex</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>HyperTerminal_HwFlowControl</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal_HwFlowControl</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal_HwFlowControl</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal_HwFlowControl</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal_HwFlowControl</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal_HwFlowControl</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>HyperTerminal_Interrupt</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal_Interrupt</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal_Interrupt</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal_Interrupt</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal_Interrupt</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal_Interrupt</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Interrupt</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Interrupt</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Interrupt</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Interrupt</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Interrupt</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Interrupt</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>MultiProcessor</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>MultiProcessor</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>MultiProcessor</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>MultiProcessor</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>MultiProcessor</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>MultiProcessor</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Polling</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Polling</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Polling</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Polling</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Polling</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Polling</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Printf</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Printf</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Printf</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Printf</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Printf</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Printf</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Receive</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Receive</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Receive</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Receive</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Receive</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Receive</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Smartcard</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Smartcard</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Smartcard</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Smartcard</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Smartcard</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Smartcard</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Synchronous</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Synchronous</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Synchronous</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Synchronous</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Synchronous</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Synchronous</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Transmit</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Transmit</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Transmit</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Transmit</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Transmit</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Transmit</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
