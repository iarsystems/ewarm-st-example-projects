<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Backup_Data/Backup_Data.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Tamper/Tamper.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Backup_Data</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Backup_Data</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Backup_Data</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Backup_Data</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Backup_Data</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Backup_Data</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>Tamper</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>Tamper</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>Tamper</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>Tamper</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>Tamper</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>Tamper</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
