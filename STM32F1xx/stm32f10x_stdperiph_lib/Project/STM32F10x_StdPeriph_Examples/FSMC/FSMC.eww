<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/NOR_CodeExecute/binary/Binary.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/NAND/NAND.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/NOR/NOR.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/NOR_CodeExecute/NOR_CodeExecute.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OneNAND/OneNAND.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SRAM/SRAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SRAM_DataMemory/SRAM_DataMemory.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Binary</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>NAND</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>NAND</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>NAND</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>NAND</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>NAND</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>NAND</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>NOR</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>NOR</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>NOR</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>NOR</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>NOR</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>NOR</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>NOR_CodeExecute</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>NOR_CodeExecute</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>NOR_CodeExecute</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>NOR_CodeExecute</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>NOR_CodeExecute</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>NOR_CodeExecute</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>OneNAND</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>OneNAND</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>OneNAND</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>OneNAND</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>OneNAND</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>OneNAND</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>SRAM</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>SRAM</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>SRAM</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>SRAM</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>SRAM</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>SRAM</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>SRAM_DataMemory</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>SRAM_DataMemory</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>SRAM_DataMemory</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>SRAM_DataMemory</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>SRAM_DataMemory</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>SRAM_DataMemory</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
