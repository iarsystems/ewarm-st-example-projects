# IAR project AudioStreaming.ewp, settings and files
configuration STM3210C-EVAL-25MHz (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL; EXTERNAL_CRYSTAL_25MHz; HSE_VALUE=25000000
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Core\Include; ..\inc; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM3210C-EVAL_AudioStreaming_25MHz.bin
  ILINK.IlinkOutputFile: AudioStreaming.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210C-EVAL-14MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL; EXTERNAL_CRYSTAL_14_7456MHz; HSE_VALUE=14745600
  OBJCOPY.OOCOutputFile: STM3210C-EVAL_AudioStreaming_14MHz.bin
  group CMSIS
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../src/: system_stm32f10x.c
  group Doc
    ../: readme.txt
  group STM3210C_EVAL
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval.c stm3210c_eval_ioe.c
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: audio_codec_cs43l22.c hw_config.c main.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
