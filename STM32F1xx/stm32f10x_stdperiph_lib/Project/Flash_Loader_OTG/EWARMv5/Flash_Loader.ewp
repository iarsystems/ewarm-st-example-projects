# IAR project Flash_Loader.ewp, settings and files
configuration USBF_HID (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VC ST STM32F103VC
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flash_Loader.srec
  ILINK.IlinkOutputFile: Flash_Loader.out
  ILINK.IlinkKeepSymbols: DEMO
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration USBF_MSC (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
configuration USBH_MSC (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
configuration USBH_HID (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
configuration USBO_DRD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
configuration USBH_MSC_MP3_25MHz (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
configuration USBH_MSC_MP3_14-7456MHz (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
configuration USBH_MSC_WAV_25MHz (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
configuration USBH_MSC_WAV_14-7456MHz (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  group (top)
    ./: main.c
