<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RTC_LSI/EWARM/RTC_LSI.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RTC_LSI</project>
        <configuration>STM3210C_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
