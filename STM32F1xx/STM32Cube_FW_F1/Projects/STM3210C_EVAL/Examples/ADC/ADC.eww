<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_DualModeInterleaved/EWARM/ADC_DualModeInterleaved.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_Regular_injected_groups/EWARM/ADC_Regular_injected_groups.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_DualModeInterleaved</project>
        <configuration>STM3210C_EVAL</configuration>
      </member>
      <member>
        <project>ADC_Regular_injected_groups</project>
        <configuration>STM3210C_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
