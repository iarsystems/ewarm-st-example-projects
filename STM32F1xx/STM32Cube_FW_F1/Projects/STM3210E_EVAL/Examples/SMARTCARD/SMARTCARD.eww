<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SMARTCARD_T0/EWARM/SMARTCARD_T0.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SMARTCARD_T0</project>
        <configuration>STM3210E_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
