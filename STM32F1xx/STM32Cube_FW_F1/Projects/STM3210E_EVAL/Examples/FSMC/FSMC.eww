<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/FSMC_NAND/EWARM/FSMC_NAND.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FSMC_NOR/EWARM/FSMC_NOR.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FSMC_NOR_CodeExecute/EWARM/FSMC_NOR_CodeExecute.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FSMC_SRAM/EWARM/FSMC_SRAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FSMC_SRAM_DataMemory/EWARM/FSMC_SRAM_DataMemory.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>FSMC_NAND</project>
        <configuration>STM3210E_EVAL</configuration>
      </member>
      <member>
        <project>FSMC_NOR</project>
        <configuration>STM3210E_EVAL</configuration>
      </member>
      <member>
        <project>FSMC_NOR_CodeExecute</project>
        <configuration>STM3210E_EVAL</configuration>
      </member>
      <member>
        <project>FSMC_SRAM</project>
        <configuration>STM3210E_EVAL</configuration>
      </member>
      <member>
        <project>FSMC_SRAM_DataMemory</project>
        <configuration>STM3210E_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
