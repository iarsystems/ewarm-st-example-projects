<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DAC_SimpleConversion/EWARM/DAC_SimpleConversion.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>DAC_SimpleConversion</project>
        <configuration>STM3210E_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
