<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/UART_HyperTerminal_DMA/EWARM/UART_HyperTerminal_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_Printf/EWARM/UART_Printf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_TwoBoards_ComDMA/EWARM/UART_TwoBoards_ComDMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_TwoBoards_ComIT/EWARM/UART_TwoBoards_ComIT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_TwoBoards_ComPolling/EWARM/UART_TwoBoards_ComPolling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>UART_HyperTerminal_DMA</project>
        <configuration>STM32VL-Discovery</configuration>
      </member>
      <member>
        <project>UART_Printf</project>
        <configuration>STM32VL-Discovery</configuration>
      </member>
      <member>
        <project>UART_TwoBoards_ComDMA</project>
        <configuration>STM32VL-Discovery</configuration>
      </member>
      <member>
        <project>UART_TwoBoards_ComIT</project>
        <configuration>STM32VL-Discovery</configuration>
      </member>
      <member>
        <project>UART_TwoBoards_ComPolling</project>
        <configuration>STM32VL-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
