<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/PWR_SLEEP/EWARM/PWR_SLEEP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>PWR_SLEEP</project>
        <configuration>STM32VL-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
