# IAR project Template.ewp, settings and files
configuration STM32VL-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100RB ST STM32F100RB
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F100xB; USE_STM32VL_DISCO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32VL-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32VL_DISCOVERY.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f100xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Example/EWARM
    ./: startup_stm32f100xb.s
  group Drivers/BSP/STM32VL-Discovery
    ../../../../Drivers/BSP/STM32VL-Discovery/: stm32vl_discovery.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_spi.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_adc.c stm32f1xx_hal_dma.c stm32f1xx_hal_i2s.c stm32f1xx_hal_pwr.c stm32f1xx_hal_spi_ex.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_eth.c stm32f1xx_hal_irda.c stm32f1xx_hal_rcc.c stm32f1xx_hal_sram.c stm32f1xx_ll_usb.c stm32f1xx_hal_can.c stm32f1xx_hal_flash.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_cec.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_nand.c stm32f1xx_hal_rtc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_nor.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_crc.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pccard.c stm32f1xx_hal_sd.c stm32f1xx_hal_usart.c stm32f1xx_hal_dac.c stm32f1xx_hal_hcd.c stm32f1xx_hal_pcd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_wwdg.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
