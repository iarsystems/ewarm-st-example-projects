# IAR project STM32F103ZE_IAR_SK_Demo.ewp, settings and files
configuration STM32F103ZE-SK (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: VECT_TAB_FLASH; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Core\Include; ..\; ..\..\..\library\STM32F10x_StdPeriph_Driver\inc\; ..\..\..\library\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; ..\..\Drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/Accelerometer
    ../../Drivers/: accl_drv.c
  group Drivers/Font
    ../../Drivers/: iar_logo.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group Drivers/FSMC
    ../../Drivers/: fsmc_sram.c
  group Drivers/GLCD
    ../../Drivers/: drv_glcd.c glcd_ll.c
  group Drivers/I2C
    ../../Drivers/: i2c2_drv.c
  group Drivers/SD
    ../../Drivers/: sdcard.c
  group Drivers/Step_Motor
    ../../Drivers/: step_motor_drv.c
  group Drivers/Temp.Sensor
    ../../Drivers/: temp_sensor_drv.c
  group Drivers/USB/Class
    ../../Drivers/: audio_class.c usb_dev_desc.c usb_hooks.c
  group Drivers/USB/Core
    ../../Drivers/: usb_buffer.c usb_t9.c
  group Drivers/USB/HW
    ../../Drivers/: usb_hw.c
  group EWARMv5/CMSIS
    ../../../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../../../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FWLib
    ../../../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Test
    ../../Test/: Accelerometer_Test.c Button_Test.c Buzzer_Test.c Ext_SRAM_Test.c LED_Test.c Potentiometer_Test.c SD_Card_Test.c Stepper_Motor_Test.c Temp_Sensor_Test.c USART1_Test.c USART2_Test.c USB_Test.c
  group User
    ../: main.c menu.c stm32f10x_it.c
