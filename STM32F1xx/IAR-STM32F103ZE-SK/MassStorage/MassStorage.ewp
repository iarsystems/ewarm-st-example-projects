# IAR project MassStorage.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; app\; board\; modules\; ..\library\STM32F10x_StdPeriph_Driver\inc\; ..\library\CMSIS\CM3\DeviceSupport\ST\STM32F10x\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MassStorage.out
  ILINK.IlinkIcfFile: config/STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: main.c stm32f10x_conf.h
    ./: readme.txt
  group CMSIS
    ../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Fonts
    app/: Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group LUN
    app/: lun.c sd_dsk_desc.c
  group LUN/SD/MMC
    app/: sd_card_mode.c
  group Modules/NokiaCGLCD/Comon
    modules/: drv_glcd.c
  group Modules/NokiaCGLCD/Config
    modules/: drv_glcd_cnfg.h
  group Modules/NokiaCGLCD/HW
    modules/: glcd_ll.c
  group Pictures
    app/: iar_logo.c
  group StdPeriph_Driver
    ../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB/Class
    app/: scsi.c scsi_ll.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
  group Vectors
    app/: stm32f10x_it.c
