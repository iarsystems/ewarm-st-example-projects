# IAR project GettingStarted.ewp, settings and files
configuration DDR2 Debug (ARM, debug)
  General.OGChipSelectEditMenu: SPEAr300 ST SPEAr300
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; board\; modules\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/spear300_ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Serial NOR Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkProgramEntryLabel: __boot_entry
  group (top)
    ./: main.c readme.txt
  group MMU
    modules/: arm926ej_cp15_drv.c
    board/: ttbl.c
  group Startup
    board/: bootloader.c bootstartup.s header.c SPEAR300_cstartup.s
