# IAR project Core2.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: SR5E1E7_1 ST SR5E1E7_1
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEVICE_NAME=sr5e1; BOARD_NAME=evbe7000p; BUILD_BOOT; BUILD_PLATFORM_BOARD; BUILD_PLATFORM_CLOCK; BUILD_PLATFORM_CMSIS; BUILD_PLATFORM_IRQ; BUILD_PLATFORM_MCU; BUILD_DRIVERS_GPIO; BUILD_OS_OSAL; BUILD_OS_OSAL=1
  ICCARM.CCIncludePath2: ..\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Core2.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: sr5e1x_ram_core2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: sr5e1x_nvm_core2.icf
  group (top)
    ../Src/: clock.c crt1.c cstartup.S gpio.c irq.c main_core2.c osal.c test_env.c vectors.S
    ../: readme.txt
