# IAR project GettingStarted.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR912Fx44 ST STR912Fx44
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCIncludePath2: ; ..\..\STR91xlibrary\include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config/STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 91x_conf.h 91x_it.c main.c
  group Startup
    ./: 91x_init.s 91x_vect.s
  group STR91x_lib
    ../../STR91xlibrary/source/: 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_scu.c 91x_tim.c 91x_vic.c 91x_wiu.c
