<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/USBMouse.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USBMouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>USBMouse</project>
        <configuration>J-Trace debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
