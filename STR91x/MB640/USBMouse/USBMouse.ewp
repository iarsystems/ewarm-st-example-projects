# IAR project USBMouse.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR912Fx44 ST STR912Fx44
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; app\; board\; module\; ..\..\STR91xlibrary\include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: USBMouse.out
  ILINK.IlinkIcfFile: CONFIG/STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: 91x_conf.h 91x_it.c buttons.c hid_mouse.c main.c
  group Common
    app/: 91x_init.s 91x_vect.s
  group Module
    module/: STR91x_USB.c
  group STR91x_lib
    ../../STR91xlibrary/source/: 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_scu.c 91x_tim.c 91x_vic.c
  group USB
    app/: usb_dev_desc.c
