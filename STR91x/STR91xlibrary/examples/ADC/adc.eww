<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/interrupt/adc_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/polling/adc_pol.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>adc_int</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>adc_pol</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
