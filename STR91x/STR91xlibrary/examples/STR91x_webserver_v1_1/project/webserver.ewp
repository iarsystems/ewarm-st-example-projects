# IAR project webserver.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912Fx44 ST STR912Fx44
  ICCARM.CCIncludePath2: ; ..\..\..\include; ..\uip\; ..\ethernet_lib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: webserver.out
  ILINK.IlinkIcfFile: ../../../linker/STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 91x_it.c main.c
  group ethernet_lib
    ../ethernet_lib/: 91x_enet.c memcopy.s
  group startup
    ../../../startup/: 91x_init.s 91x_vect.s
  group STR91xlibrary
    ../../../source/: 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_scu.c
  group uIP
    ../uip/: cgi.c fs.c httpd.c uip.c uip_arch.c uip_arp.c uIPMain.c
