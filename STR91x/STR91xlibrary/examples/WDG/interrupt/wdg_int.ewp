# IAR project wdg_int.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912Fx44 ST STR912Fx44
  ICCARM.CCIncludePath2: ..\..\..\include; $PROJ_DIR$
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: wdg_int.out
  ILINK.IlinkIcfFile: ../../../linker/STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 91x_it.c main.c
  group source
    ../../../source/: 91x_gpio.c 91x_lib.c 91x_scu.c 91x_vic.c 91x_wdg.c
  group startup
    ../../../startup/: 91x_init.s 91x_vect.s
