# IAR project STR91x_Configuration_Bits.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912Fx44 ST STR912Fx44
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: STR91x_Configuration_Bits.out
  ILINK.IlinkIcfFile: STR91x_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
