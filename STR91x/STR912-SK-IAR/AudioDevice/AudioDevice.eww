<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/AudioDevice.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>AudioDevice</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>AudioDevice</project>
        <configuration>J-Trace debug</configuration>
      </member>
      <member>
        <project>AudioDevice</project>
        <configuration>Debug Remap Bank 1</configuration>
      </member>
      <member>
        <project>AudioDevice</project>
        <configuration>J-Trace debug Remap Bank 1</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
