# IAR project AudioDevice.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR912Fx44 ST STR912Fx44
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; app\; board\; module\; ..\..\STR91xlibrary\include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: AudioDevice.out
  ILINK.IlinkIcfFile: config/STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug Remap Bank 1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Remap_Bank_1
  AARM.ADefines: Remap_Bank_1
  OBJCOPY.OOCOutputFile: AudioDevice.srec
  ILINK.IlinkIcfFile: config/STR91x_FLASH2.icf
  group (top)
    app/: 91x_conf.h 91x_it.c audio_class.c main.c
    module/: STR91x_usb_cfg.h
  group Common
    app/: 91x_init.s 91x_vect.s
  group Module
    module/: drv_hd44780.c drv_hd44780_l.c STR91x_USB.c
  group STR91x_lib
    ../../STR91xlibrary/source/: 91x_adc.c 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_scu.c 91x_tim.c 91x_vic.c
  group USB
    app/: usb_dev_desc.c
