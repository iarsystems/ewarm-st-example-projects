# IAR project uip_webserver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR912Fx44 ST STR912Fx44
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pe177,Pa082
  ICCARM.CCIncludePath2: ; app; board; module; uip; uip\httpd; ..\..\STR91xlibrary\include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uip_webserver.out
  ILINK.IlinkIcfFile: CONFIG/STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug Remap Bank 1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Remap_Bank_1
  AARM.ADefines: Remap_Bank_1
  ILINK.IlinkIcfFile: config/STR91x_FLASH2.icf
  group (top)
    app/: 91x_conf.h 91x_it.c clock-arch.c main.c uip-conf.h
    uip/: uipopt.h
  group Common
    app/: 91x_init.s 91x_vect.s
  group Module
    module/: drv_hd44780.c drv_hd44780_l.c STR912_enet.c
  group SIT91x_lib
    ../../STR91xlibrary/source/: 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_scu.c 91x_tim.c 91x_vic.c
  group uIP
    uip/: psock.c timer.c uip.c uip_arp.c
  group uIP/http
    uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
