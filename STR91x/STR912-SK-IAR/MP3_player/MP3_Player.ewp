# IAR project MP3_Player.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR912Fx44 ST STR912Fx44
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; app\; board\; module\; ..\..\STR91xlibrary\include\; arm7_efsl_0_2_7\inc\; arm7_efsl_0_2_7\inc\interfaces\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MP3_Player.out
  ILINK.IlinkIcfFile: CONFIG/STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug Remap Bank 1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Remap_Bank_1
  AARM.ADefines: Remap_Bank_1
  ILINK.IlinkIcfFile: config/STR91x_FLASH2.icf
  group (top)
    app/: 91x_conf.h 91x_it.c keys.c main.c
  group Common
    app/: 91x_init.s 91x_vect.s
  group efs
    arm7_efsl_0_2_7/inc/: config.h
    arm7_efsl_0_2_7/src/: dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ioman_v2.c ls.c mkfs.c partition.c plibc.c time.c ui.c
  group Module
    module/: arm_spi.c drv_hd44780.c drv_hd44780_l.c drv_vs1002.c mmc.c
  group STR91x_lib
    ../../STR91xlibrary/source/: 91x_adc.c 91x_dma.c 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_scu.c 91x_ssp.c 91x_tim.c 91x_vic.c
