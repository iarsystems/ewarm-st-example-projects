# IAR project lwipWebserver.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; app\; app\httpserver; modules\; board\; lwip_v1.3.2\port\STM32F2x7\Standalone\; lwip_v1.3.2\port\STM32F2x7\; lwip_v1.3.2\src\include\; lwip_v1.3.2\src\include\lwip\; lwip_v1.3.2\src\include\ipv4\; lwip_v1.3.2\src\include\netif\; ..\Libraries\CMSIS\CM3\CoreSupport; ..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\Libraries\STM32F2x7_ETH_Driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    app/: iar_logo.c main.c stm32f2xx_it.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group app/httpserver
    app/httpserver/: fs.c httpd.c httpd_cgi_ssi.c netconf.c
  group board
    board/: iar_stm32f207zg_sk.c
  group lwIP/Api
    lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwIP/Core
    lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwIP/Core/IPv4
    lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwIP/Netif
    lwip_v1.3.2/src/netif/: etharp.c
    lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group modules
    modules/: drv_glcd.c glcd_ll.c
  group startup
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group STM32F2x7_ETH_Driver
    ../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM32F2xx_StdPeriph_Driver
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
