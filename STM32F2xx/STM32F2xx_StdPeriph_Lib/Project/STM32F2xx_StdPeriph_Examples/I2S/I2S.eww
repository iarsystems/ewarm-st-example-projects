<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Audio/Audio.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Audio</project>
        <configuration>STM322xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
