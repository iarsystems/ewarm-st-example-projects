<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DataExchangeDMA/DataExchangeDMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DataExchangeInterrupt/DataExchangeInterrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/EEPROM/EEPROM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/IOE/IOE.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/MasterReceiverInterrupt/MasterReceiverInterrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/MasterTransmitterInterrupt/MasterTransmitterInterrupt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>DataExchangeDMA</project>
        <configuration>STM322xG_EVAL</configuration>
      </member>
      <member>
        <project>DataExchangeInterrupt</project>
        <configuration>STM322xG_EVAL</configuration>
      </member>
      <member>
        <project>EEPROM</project>
        <configuration>STM322xG_EVAL</configuration>
      </member>
      <member>
        <project>IOE</project>
        <configuration>STM322xG_EVAL</configuration>
      </member>
      <member>
        <project>MasterReceiverInterrupt</project>
        <configuration>STM322xG_EVAL</configuration>
      </member>
      <member>
        <project>MasterTransmitterInterrupt</project>
        <configuration>STM322xG_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
