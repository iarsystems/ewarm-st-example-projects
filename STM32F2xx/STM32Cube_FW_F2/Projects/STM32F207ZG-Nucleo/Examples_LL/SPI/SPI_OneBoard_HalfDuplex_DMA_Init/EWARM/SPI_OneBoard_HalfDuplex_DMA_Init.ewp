# IAR project SPI_OneBoard_HalfDuplex_DMA_Init.ewp, settings and files
configuration NUCLEO-F207ZG (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F207xx; USE_FULL_LL_DRIVER; HSE_VALUE=8000000U
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\..\..\..\Drivers\STM32F2xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NUCLEO-F207ZG.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f207xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32f2xx_it.c
  group Example/EWARM
    ./: startup_stm32f207xx.s
  group Drivers/STM32F2xx_LL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_utils.c stm32f2xx_ll_spi.c stm32f2xx_ll_rcc.c stm32f2xx_ll_rcc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
