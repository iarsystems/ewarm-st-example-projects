<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TIM_BreakAndDeadtime/EWARM/TIM_BreakAndDeadtime.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_DMA/EWARM/TIM_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_InputCapture/EWARM/TIM_InputCapture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_OnePulse/EWARM/TIM_OnePulse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_OutputCompare/EWARM/TIM_OutputCompare.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PWMOutput/EWARM/TIM_PWMOutput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PWMOutput_Init/EWARM/TIM_PWMOutput_Init.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_TimeBase/EWARM/TIM_TimeBase.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TIM_BreakAndDeadtime</project>
        <configuration>NUCLEO-F207ZG</configuration>
      </member>
      <member>
        <project>TIM_DMA</project>
        <configuration>NUCLEO-F207ZG</configuration>
      </member>
      <member>
        <project>TIM_InputCapture</project>
        <configuration>NUCLEO-F207ZG</configuration>
      </member>
      <member>
        <project>TIM_OnePulse</project>
        <configuration>NUCLEO-F207ZG</configuration>
      </member>
      <member>
        <project>TIM_OutputCompare</project>
        <configuration>NUCLEO-F207ZG</configuration>
      </member>
      <member>
        <project>TIM_PWMOutput</project>
        <configuration>NUCLEO-F207ZG</configuration>
      </member>
      <member>
        <project>TIM_PWMOutput_Init</project>
        <configuration>NUCLEO-F207ZG</configuration>
      </member>
      <member>
        <project>TIM_TimeBase</project>
        <configuration>NUCLEO-F207ZG</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
