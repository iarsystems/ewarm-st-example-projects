<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/EXTI_ToggleLedOnIT/EWARM/EXTI_ToggleLedOnIT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/EXTI_ToggleLedOnIT_Init/EWARM/EXTI_ToggleLedOnIT_Init.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>EXTI_ToggleLedOnIT</project>
        <configuration>NUCLEO-F207ZG</configuration>
      </member>
      <member>
        <project>EXTI_ToggleLedOnIT_Init</project>
        <configuration>NUCLEO-F207ZG</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
