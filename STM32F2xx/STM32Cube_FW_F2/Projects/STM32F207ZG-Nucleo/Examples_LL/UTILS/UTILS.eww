<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/UTILS_ConfigureSystemClock/EWARM/UTILS_ConfigureSystemClock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UTILS_ReadDeviceInfo/EWARM/UTILS_ReadDeviceInfo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>UTILS_ConfigureSystemClock</project>
        <configuration>NUCLEO-F207ZG</configuration>
      </member>
      <member>
        <project>UTILS_ReadDeviceInfo</project>
        <configuration>NUCLEO-F207ZG</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
