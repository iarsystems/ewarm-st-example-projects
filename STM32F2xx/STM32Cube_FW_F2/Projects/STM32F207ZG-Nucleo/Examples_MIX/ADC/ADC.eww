<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_SingleConversion_TriggerSW_IT/EWARM/ADC_SingleConversion_TriggerSW_IT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_SingleConversion_TriggerSW_IT</project>
        <configuration>STM32F207ZG-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
