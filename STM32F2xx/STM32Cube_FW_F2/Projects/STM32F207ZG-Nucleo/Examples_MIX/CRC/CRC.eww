<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CRC_CalculateAndCheck/EWARM/CRC_CalculateAndCheck.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CRC_CalculateAndCheck</project>
        <configuration>STM32F207ZG-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
