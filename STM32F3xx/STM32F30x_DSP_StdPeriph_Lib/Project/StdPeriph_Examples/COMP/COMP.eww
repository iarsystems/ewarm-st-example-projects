<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/AnalogWatchdog/AnalogWatchdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Hygrometer/Hygrometer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LDR/LDR.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OutputBlanking/OutputBlanking.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PulseWidthMeasurement/PulseWidthMeasurement.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWMSignalControl/PWMSignalControl.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>AnalogWatchdog</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>Hygrometer</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>LDR</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>OutputBlanking</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>PulseWidthMeasurement</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>PWMSignalControl</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
