<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/6Steps/6Steps.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/7PWMOutputs/7PWMOutputs.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Asymetric/Asymetric.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Combined/Combined.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ComplementarySignals/Complementary_Signals.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DMA_Burst/DMA_Burst.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/EncoderMode/EncoderMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/InputCapture/InputCapture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OCActive/OCActive.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OCToggle/OCToggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OnePulse/OnePulse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWMInput/PWMInput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RetriggreableOPM/RetriggreableOPM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Synchronization/Synchronization.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TimeBase/Time_Base.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>6Steps</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>7PWMOutputs</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>Asymetric</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>Combined</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>Complementary_Signals</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>DMA_Burst</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>EncoderMode</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>InputCapture</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>OCActive</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>OCToggle</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>OnePulse</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>PWMInput</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>RetriggreableOPM</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>Synchronization</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>Time_Base</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
