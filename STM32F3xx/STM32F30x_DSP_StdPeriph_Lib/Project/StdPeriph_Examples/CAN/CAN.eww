<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DualFIFO/Dual_FIFO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FIFO_Extension/FIFO_Extension.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LoopBack/LoopBack.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Networking/Networking.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Dual_FIFO</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>FIFO_Extension</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>LoopBack</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>Networking</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
