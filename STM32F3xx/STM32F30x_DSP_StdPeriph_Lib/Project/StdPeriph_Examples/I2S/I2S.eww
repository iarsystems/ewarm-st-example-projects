<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/FullDuplexDataExchangeDMA/FullDuplexDataExchangeDMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FullDuplexDataExchangeIT/FullDuplexDataExchangeIT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>FullDuplexDataExchangeDMA</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>FullDuplexDataExchangeIT</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
