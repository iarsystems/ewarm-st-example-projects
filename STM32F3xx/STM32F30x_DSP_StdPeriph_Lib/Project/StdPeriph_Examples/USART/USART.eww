<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/AutoBaudRate/AutoBaudRate.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DataExchangeDMA/DataExchangeDMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DataExchangeInterrupt/DataExchangeInterrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HyperTerminalInterrupt/HyperTerminal_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Printf/Printf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/WakeUpFromStop/WakeUpFromStop.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>AutoBaudRate</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>DataExchangeDMA</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>DataExchangeInterrupt</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>HyperTerminal_Interrupt</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>Printf</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>WakeUpFromStop</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
