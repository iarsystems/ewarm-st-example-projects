<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/AnalogWatchdog/AnalogWatchdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/BasicExample/BasicExample.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DifferentialMode/DifferentialMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/DualMode/DualMode.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>AnalogWatchdog</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>BasicExample</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>DifferentialMode</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>DualMode</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
