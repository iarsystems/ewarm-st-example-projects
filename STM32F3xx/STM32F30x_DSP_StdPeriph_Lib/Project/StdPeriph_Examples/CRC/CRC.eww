<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/32BitsCRC_Message/32BitsCRCMessage.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/8BitsCRC_Message/8BitsCRCMessage.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TwoBoards/CRC_TwoBoards.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>32BitsCRCMessage</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>8BitsCRCMessage</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
      <member>
        <project>CRC_TwoBoards</project>
        <configuration>STM32303C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
