# IAR project I2C_WakeUpFromStop.ewp, settings and files
configuration STM32373C-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F373VC ST STM32F373VC
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_STM32373C_EVAL; STM32F37X
  ICCARM.CCIncludePath2: ; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F37x\Include; ..\..\..\..\Libraries\STM32F37x_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32F37x_CPAL_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM32373C_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32F373-EVAL.out
  ILINK.IlinkIcfFile: stm32f37x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group CMSIS
    ./: system_stm32f37x.c
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F37x/Source/Templates/iar/: startup_stm32f37x.s
  group StdPeriph_Drivers
    ../../../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_adc.c stm32f37x_can.c stm32f37x_cec.c stm32f37x_comp.c stm32f37x_crc.c stm32f37x_dac.c stm32f37x_dbgmcu.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_iwdg.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_rtc.c stm32f37x_sdadc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_wwdg.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/STM32373C_EVAL/: stm32373c_eval.c stm32373c_eval_lcd.c
    ../../../../Libraries/STM32F37x_CPAL_Driver/src/: stm32f37x_i2c_cpal.c stm32f37x_i2c_cpal_hal.c
  group User
    ./: main.c stm32f37x_i2c_cpal_usercallback.c stm32f37x_it.c
