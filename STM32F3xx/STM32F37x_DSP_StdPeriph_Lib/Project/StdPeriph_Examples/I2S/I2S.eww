<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/I2S_DataExchangeDMA/I2S_DataExchangeDMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2S_DataExchangeInterrupt/I2S_DataExchangeInterrupt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>I2S_DataExchangeDMA</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>I2S_DataExchangeInterrupt</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
