<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/NVIC_IRQMask/NVIC_IRQMask.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/NVIC_IRQPriority/NVIC_IRQPriority.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/NVIC_WFIMode/NVIC_WFIMode.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>NVIC_IRQMask</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>NVIC_IRQPriority</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>NVIC_WFIMode</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
