<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CAN_DualFIFO/CAN_DualFIFO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CAN_FIFOExtension/CAN_FIFOExtension.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CAN_LoopBack/CAN_LoopBack.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CAN_Networking/CAN_Networking.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>CAN_DualFIFO</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>CAN_FIFOExtension</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>CAN_LoopBack</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>CAN_Networking</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
