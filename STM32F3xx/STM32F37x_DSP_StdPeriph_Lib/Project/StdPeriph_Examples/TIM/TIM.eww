<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TIM_DMABurst/TIM_DMABurst.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_EncoderMode/TIM_EncoderMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_InputCapture/TIM_InputCapture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_OCActive/TIM_OCActive.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_OCToggle/TIM_OCToggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_OnePulse/TIM_OnePulse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PWMInput/TIM_PWMInput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_Synchronization/TIM_Synchronization.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_TimeBase/TIM_TimeBase.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>TIM_DMABurst</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>TIM_EncoderMode</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>TIM_InputCapture</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>TIM_OCActive</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>TIM_OCToggle</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>TIM_OnePulse</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>TIM_PWMInput</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>TIM_Synchronization</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>TIM_TimeBase</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
