<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CEC_DataExchange/CEC_DataExchange.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CEC_ListenMode/CEC_ListenMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CEC_MultiAddress/CEC_MultiAddress.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>CEC_DataExchange</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>CEC_ListenMode</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>CEC_MultiAddress</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
