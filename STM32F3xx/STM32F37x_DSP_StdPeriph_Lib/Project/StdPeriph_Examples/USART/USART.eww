<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/USART_AutoBaudRate/USART_AutoBaudRate.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_DataExchangeDMA/USART_DataExchangeDMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_DataExchangeInterrupt/USART_DataExchangeInterrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_HyperTerminalInterrupt/USART_HyperTerminalInterrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_Printf/USART_Printf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_WakeUpFromStop/USART_WakeUpFromStop.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USART_AutoBaudRate</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>USART_DataExchangeDMA</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>USART_DataExchangeInterrupt</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>USART_HyperTerminalInterrupt</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>USART_Printf</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>USART_WakeUpFromStop</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
