<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/COMP_AnalogWatchdog/COMP_AnalogWatchdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/COMP_LDR/COMP_LDR.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/COMP_PulseWidthMeasurement/COMP_PulseWidthMeasurement.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/COMP_PWMSignalControl/COMP_PWMSignalControl.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>COMP_AnalogWatchdog</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>COMP_LDR</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>COMP_PulseWidthMeasurement</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>COMP_PWMSignalControl</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
