<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CRC_32BitsCRCMessage/CRC_32BitsCRCMessage.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRC_8BitsCRCMessage/CRC_8BitsCRCMessage.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRC_TwoBoards/CRC_TwoBoards.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>CRC_32BitsCRCMessage</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>CRC_8BitsCRCMessage</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>CRC_TwoBoards</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
