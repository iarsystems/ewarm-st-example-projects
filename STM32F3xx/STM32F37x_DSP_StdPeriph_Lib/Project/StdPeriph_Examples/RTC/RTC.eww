<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RTC_Calendar/RTC_Calendar.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RTC_LSI/RTC_LSI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RTC_StopWatch/RTC_StopWatch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RTC_Tamper/RTC_Tamper.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/RTC_Timer/RTC_Timer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>RTC_Calendar</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>RTC_LSI</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>RTC_StopWatch</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>RTC_Tamper</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
      <member>
        <project>RTC_Timer</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
