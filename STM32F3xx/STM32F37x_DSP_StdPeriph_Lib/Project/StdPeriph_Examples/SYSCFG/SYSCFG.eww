<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SYSCFG_PVD/SYSCFG_PVD.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>SYSCFG_PVD</project>
        <configuration>STM32373C-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
