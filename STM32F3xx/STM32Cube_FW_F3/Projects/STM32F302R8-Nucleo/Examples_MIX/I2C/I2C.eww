<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/I2C_OneBoard_ComSlave7_10bits_IT/EWARM/I2C_OneBoard_ComSlave7_10bits_IT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>I2C_OneBoard_ComSlave7_10bits_IT</project>
        <configuration>STM32F302R8-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
