<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/I2C_OneBoard_AdvCommunication_DMAAndIT/EWARM/I2C_OneBoard_AdvCommunication_DMAAndIT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_OneBoard_Communication_DMAAndIT/EWARM/I2C_OneBoard_Communication_DMAAndIT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_OneBoard_Communication_IT/EWARM/I2C_OneBoard_Communication_IT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_OneBoard_Communication_IT_Init/EWARM/I2C_OneBoard_Communication_IT_Init.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_OneBoard_Communication_PollingAndIT/EWARM/I2C_OneBoard_Communication_PollingAndIT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>I2C_OneBoard_AdvCommunication_DMAAndIT</project>
        <configuration>STM32F302R8-Nucleo</configuration>
      </member>
      <member>
        <project>I2C_OneBoard_Communication_DMAAndIT</project>
        <configuration>STM32F302R8-Nucleo</configuration>
      </member>
      <member>
        <project>I2C_OneBoard_Communication_IT</project>
        <configuration>STM32F302R8-Nucleo</configuration>
      </member>
      <member>
        <project>I2C_OneBoard_Communication_IT_Init</project>
        <configuration>STM32F302R8-Nucleo</configuration>
      </member>
      <member>
        <project>I2C_OneBoard_Communication_PollingAndIT</project>
        <configuration>STM32F302R8-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
