<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/HRTIM_BasicPWM/EWARM/HRTIM_BasicPWM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_BuckBoost/EWARM/HRTIM_BuckBoost.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_BuckBoost_AN4449/EWARM/HRTIM_BuckBoost_AN4449.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_BuckSyncRect/EWARM/HRTIM_BuckSyncRect.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_DualBuck/EWARM/HRTIM_DualBuck.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_LLC_HalfBridge/EWARM/HRTIM_LLC_HalfBridge.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_Multiphase/EWARM/HRTIM_Multiphase.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_Snippets/EWARM/HRTIM_Snippets.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_TM_PFC/EWARM/HRTIM_TM_PFC.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>HRTIM_BasicPWM</project>
        <configuration>STM32F3348-Discovery</configuration>
      </member>
      <member>
        <project>HRTIM_BuckBoost</project>
        <configuration>STM32F3348-Discovery</configuration>
      </member>
      <member>
        <project>HRTIM_BuckBoost_AN4449</project>
        <configuration>STM32F3348-Discovery</configuration>
      </member>
      <member>
        <project>HRTIM_BuckSyncRect</project>
        <configuration>STM32F3348-Discovery</configuration>
      </member>
      <member>
        <project>HRTIM_DualBuck</project>
        <configuration>STM32F3348-Discovery</configuration>
      </member>
      <member>
        <project>HRTIM_LLC_HalfBridge</project>
        <configuration>STM32F3348-Discovery</configuration>
      </member>
      <member>
        <project>HRTIM_Multiphase</project>
        <configuration>STM32F3348-Discovery</configuration>
      </member>
      <member>
        <project>HRTIM_Snippets</project>
        <configuration>STM32F3348-Discovery</configuration>
      </member>
      <member>
        <project>HRTIM_TM_PFC</project>
        <configuration>STM32F3348-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
