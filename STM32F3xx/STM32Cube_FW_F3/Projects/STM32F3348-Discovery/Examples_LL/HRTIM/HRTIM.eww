<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/HRTIM_BuckBoost/EWARM/HRTIM_BuckBoost.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>HRTIM_BuckBoost</project>
        <configuration>STM32F3348-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
