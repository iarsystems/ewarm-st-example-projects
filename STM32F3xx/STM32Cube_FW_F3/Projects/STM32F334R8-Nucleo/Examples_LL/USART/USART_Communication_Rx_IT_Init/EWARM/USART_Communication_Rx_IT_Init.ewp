# IAR project USART_Communication_Rx_IT_Init.ewp, settings and files
configuration STM32F334R8-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F334R8 ST STM32F334R8
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F334x8; USE_STM32F3XX_NUCLEO; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F334R8-Nucleo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f334x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32f3xx_it.c
  group Example/EWARM
    ./: startup_stm32f334x8.s
  group Drivers/STM32F3xx_LL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_rcc.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
