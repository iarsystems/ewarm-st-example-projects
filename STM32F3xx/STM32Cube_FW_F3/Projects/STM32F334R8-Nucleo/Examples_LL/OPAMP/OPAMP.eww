<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/OPAMP_PGA/EWARM/OPAMP_PGA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OPAMP_PGA_Init/EWARM/OPAMP_PGA_Init.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>OPAMP_PGA</project>
        <configuration>STM32F334R8-Nucleo</configuration>
      </member>
      <member>
        <project>OPAMP_PGA_Init</project>
        <configuration>STM32F334R8-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
