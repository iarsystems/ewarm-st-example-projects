<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/OPAMP_CALIBRATION/EWARM/OPAMP_CALIBRATION.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>OPAMP_CALIBRATION</project>
        <configuration>STM32F334R8-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
