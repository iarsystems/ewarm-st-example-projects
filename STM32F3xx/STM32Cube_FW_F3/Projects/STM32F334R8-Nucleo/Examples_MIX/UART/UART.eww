<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/UART_HyperTerminal_IT/EWARM/UART_HyperTerminal_IT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_HyperTerminal_TxPolling_RxIT/EWARM/UART_HyperTerminal_TxPolling_RxIT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>UART_HyperTerminal_IT</project>
        <configuration>STM32F334R8-Nucleo</configuration>
      </member>
      <member>
        <project>UART_HyperTerminal_TxPolling_RxIT</project>
        <configuration>STM32F334R8-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
