<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_AnalogWatchdog/EWARM/ADC_AnalogWatchdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_Sequencer/EWARM/ADC_Sequencer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_AnalogWatchdog</project>
        <configuration>STM32F303ZE-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_Sequencer</project>
        <configuration>STM32F303ZE-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
