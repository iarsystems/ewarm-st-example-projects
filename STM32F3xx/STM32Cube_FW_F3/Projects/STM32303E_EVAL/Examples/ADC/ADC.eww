<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_DifferentialMode/EWARM/ADC_DifferentialMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DualMode_18Msps/EWARM/ADC_DualMode_18Msps.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_TriggerMode/EWARM/ADC_TriggerMode.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_DifferentialMode</project>
        <configuration>STM32303E_EVAL</configuration>
      </member>
      <member>
        <project>ADC_DualMode_18Msps</project>
        <configuration>STM32303E_EVAL</configuration>
      </member>
      <member>
        <project>ADC_TriggerMode</project>
        <configuration>STM32303E_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
