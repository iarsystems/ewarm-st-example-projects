<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TIM_Asymetric/EWARM/TIM_Asymetric.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_Combined/EWARM/TIM_Combined.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_ComplementarySignals/EWARM/TIM_ComplementarySignals.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_DMA/EWARM/TIM_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_InputCapture/EWARM/TIM_InputCapture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PWMInput/EWARM/TIM_PWMInput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PWMOutput/EWARM/TIM_PWMOutput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_TimeBase/EWARM/TIM_TimeBase.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TIM_Asymetric</project>
        <configuration>STM32303E_EVAL</configuration>
      </member>
      <member>
        <project>TIM_Combined</project>
        <configuration>STM32303E_EVAL</configuration>
      </member>
      <member>
        <project>TIM_ComplementarySignals</project>
        <configuration>STM32303E_EVAL</configuration>
      </member>
      <member>
        <project>TIM_DMA</project>
        <configuration>STM32303E_EVAL</configuration>
      </member>
      <member>
        <project>TIM_InputCapture</project>
        <configuration>STM32303E_EVAL</configuration>
      </member>
      <member>
        <project>TIM_PWMInput</project>
        <configuration>STM32303E_EVAL</configuration>
      </member>
      <member>
        <project>TIM_PWMOutput</project>
        <configuration>STM32303E_EVAL</configuration>
      </member>
      <member>
        <project>TIM_TimeBase</project>
        <configuration>STM32303E_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
