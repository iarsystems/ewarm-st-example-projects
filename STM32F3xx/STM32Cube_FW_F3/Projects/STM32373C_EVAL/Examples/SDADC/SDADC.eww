<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SDADC_PressureMeasurement/EWARM/SDADC_PressureMeasurement.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SDADC_TempMeasurement/EWARM/SDADC_TempMeasurement.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SDADC_Voltmeter/EWARM/SDADC_Voltmeter.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SDADC_PressureMeasurement</project>
        <configuration>STM32373C_EVAL</configuration>
      </member>
      <member>
        <project>SDADC_TempMeasurement</project>
        <configuration>STM32373C_EVAL</configuration>
      </member>
      <member>
        <project>SDADC_Voltmeter</project>
        <configuration>STM32373C_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
