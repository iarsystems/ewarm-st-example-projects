<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_Conv_Differential/EWARM/ADC_Conv_Differential.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DifferentialMode/EWARM/ADC_DifferentialMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DualModeInterleaved/EWARM/ADC_DualModeInterleaved.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DualMode_18Msps/EWARM/ADC_DualMode_18Msps.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_Polling/EWARM/ADC_RegularConversion_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_TriggerMode/EWARM/ADC_TriggerMode.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_Conv_Differential</project>
        <configuration>STM32303C_EVAL</configuration>
      </member>
      <member>
        <project>ADC_DifferentialMode</project>
        <configuration>STM32303C_EVAL</configuration>
      </member>
      <member>
        <project>ADC_DualModeInterleaved</project>
        <configuration>STM32303C_EVAL</configuration>
      </member>
      <member>
        <project>ADC_DualMode_18Msps</project>
        <configuration>STM32303C_EVAL</configuration>
      </member>
      <member>
        <project>ADC_RegularConversion_Polling</project>
        <configuration>STM32303C_EVAL</configuration>
      </member>
      <member>
        <project>ADC_TriggerMode</project>
        <configuration>STM32303C_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
