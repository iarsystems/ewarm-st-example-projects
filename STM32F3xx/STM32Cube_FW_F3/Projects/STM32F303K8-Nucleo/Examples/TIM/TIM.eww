<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TIM_DMA/EWARM/TIM_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_InputCapture/EWARM/TIM_InputCapture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_PWMOutput/EWARM/TIM_PWMOutput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_TimeBase/EWARM/TIM_TimeBase.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TIM_DMA</project>
        <configuration>STM32F303K8_NUCLEO</configuration>
      </member>
      <member>
        <project>TIM_InputCapture</project>
        <configuration>STM32F303K8_NUCLEO</configuration>
      </member>
      <member>
        <project>TIM_PWMOutput</project>
        <configuration>STM32F303K8_NUCLEO</configuration>
      </member>
      <member>
        <project>TIM_TimeBase</project>
        <configuration>STM32F303K8_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
