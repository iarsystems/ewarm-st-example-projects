# IAR project bspi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR730FZ2 ST STR730FZ2
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\include\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bspi.out
  ILINK.IlinkIcfFile: ../../../linker/STR73x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 73x_it.c main.c
  group source
    ../../../source/: 73x_bspi.c 73x_cfg.c 73x_cmu.c 73x_dma.c 73x_eic.c 73x_gpio.c 73x_lib.c 73x_prccu.c
  group startup
    ../../../startup/: 73x_init.s 73x_vect.s
