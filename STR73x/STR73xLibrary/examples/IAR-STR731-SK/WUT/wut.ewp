# IAR project wut.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR731FV2 ST STR731FV2
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\include\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: wut.out
  ILINK.IlinkIcfFile: ../../../linker/STR73x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 73x_it.c main.c
  group source
    ../../../source/: 73x_cfg.c 73x_cmu.c 73x_eic.c 73x_gpio.c 73x_lib.c 73x_prccu.c 73x_tb.c 73x_wiu.c 73x_wut.c
  group startup
    ../../../startup/: 73x_init.s 73x_vect.s
