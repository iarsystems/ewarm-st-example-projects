# IAR project flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR731FV2 ST STR731FV2
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\include\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: flash.out
  ILINK.IlinkIcfFile: ../../../linker/STR73x_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 73x_it.c main.c
  group source
    ../../../source/: 73x_flash.c 73x_lib.c
  group startup
    ../../../startup/: 73x_init.s 73x_vect.s
