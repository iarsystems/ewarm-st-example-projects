# IAR project STR730_LCD.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STR730FZ2 ST STR730FZ2
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_REV=1
  ICCARM.CCIncludePath2: ; app\; board\; module\; STR73x_lib\include\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STR730_LCD.srec
  ILINK.IlinkOutputFile: STR730_LCD.out
  ILINK.IlinkIcfFile: config/STR73x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    app/: 73x_it.c main.c user_func.c
  group Module
    module/: drv_hd44780.c drv_hd44780_l.c menu.c menu_table.c ntc.c temp_measure.c temperature.c
  group startup
    STR73x_lib/startup/: 73x_init.s 73x_vect.s
  group STR73x_lib
    STR73x_lib/source/: 73x_adc.c 73x_bspi.c 73x_can.c 73x_cfg.c 73x_cmu.c 73x_dma.c 73x_eic.c 73x_flash.c 73x_gpio.c 73x_i2c.c 73x_lib.c 73x_prccu.c 73x_pwm.c 73x_rtc.c 73x_tb.c 73x_tim.c 73x_uart.c 73x_wdg.c 73x_wiu.c 73x_wut.c
