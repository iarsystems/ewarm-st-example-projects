# IAR project STR710-EVAL.ewp, settings and files
configuration debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR710FZ2 ST STR710FZ2
  ICCARM.CCIncludePath2: include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: STR710-Eval.out
  ILINK.IlinkIcfFile: linker/STR71x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: linker/STR71x_RAM.icf
  group (top)
    ./: 71x_it.c main.c
  group startup
    startup/: 71x_init.s 71x_vect.s
