# IAR project bspi.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR711FR2 ST STR711FR2
  ICCARM.CCDiagSuppress: Pe549
  ICCARM.CCIncludePath2: ; ..\..\include\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: bspi.out
  ILINK.IlinkIcfFile: ../../linker/STR71x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 71x_it.c main.c
  group source
    ../../source/: 71x_lib.c bspi.c gpio.c
  group startup
    ../../startup/: 71x_init.s 71x_vect.s
