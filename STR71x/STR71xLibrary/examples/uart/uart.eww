<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/interrupt/uart_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/polling/uart_poll.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>uart_int</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_poll</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
