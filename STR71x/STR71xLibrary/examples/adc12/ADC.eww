<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/adc_int/adc_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/polling/adc_poll.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>adc_int</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>adc_poll</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
