# IAR project i2c.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR711FR2 ST STR711FR2
  ICCARM.CCDiagSuppress: Pe550 ,Pa082
  ICCARM.CCIncludePath2: ; ..\..\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: i2c.out
  ILINK.IlinkIcfFile: ../../linker/STR71x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 71x_it.c main.c
  group source
    ../../source/: 71x_lib.c gpio.c i2c.c rccu.c
  group startup
    ../../startup/: 71x_init.s 71x_vect.s
