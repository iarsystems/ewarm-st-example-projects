# IAR project usb_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR711FR2 ST STR711FR2
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pe188 , Pe514, Pe550,Pe815, Pa082,Pe260
  ICCARM.CCIncludePath2: application_files\mouse_demo; core_files
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: usb_demo.out
  ILINK.IlinkIcfFile: linker/STR71x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group application_files\mouse_demo
    application_files/mouse_demo/: 71x_it.c 71x_lib.c apb.c gpio.c pcu.c rccu.c uart.c usb_desc.c usb_endp.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_rw.c xti.c
  group core_files
    core_files/: usb_core.c usb_init.c usb_int.c usb_regs.c
  group startup
    startup/: 71x_init.s 71x_vect.s
