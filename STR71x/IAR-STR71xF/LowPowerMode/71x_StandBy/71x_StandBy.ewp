# IAR project 71x_StandBy.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STR711FR2 ST STR711FR2
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; ..\include\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: 71x_StandBy.out
  ILINK.IlinkIcfFile: ../linker/STR71x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group source
    ../source/: 71x_it.c 71x_lib.c apb.c eic.c gpio.c LPmode.c rccu.c rtc.c xti.c
  group startup
    ../startup/: 71x_init.s 71x_vect.s
