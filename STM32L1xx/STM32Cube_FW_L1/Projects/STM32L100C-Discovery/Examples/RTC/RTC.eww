<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RTC_Alarm/EWARM/RTC_Alarm.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RTC_Alarm</project>
        <configuration>STM32L100C-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
