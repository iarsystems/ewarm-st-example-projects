<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/PWR_STOP/EWARM/PWR_STOP.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>PWR_STOP</project>
        <configuration>STM32L100C-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
