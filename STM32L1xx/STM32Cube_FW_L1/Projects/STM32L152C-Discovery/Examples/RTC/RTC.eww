<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/RTC_Tamper/EWARM/RTC_Tamper.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RTC_Tamper</project>
        <configuration>STM32L152C-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
