<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/COMP_Interrupt/EWARM/COMP_Interrupt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>COMP_Interrupt</project>
        <configuration>STM32L152C-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
