# IAR project ADC_AnalogWatchdog.ewp, settings and files
configuration STM32L152C-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RC ST STM32L152RC
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xC; USE_STM32L152C_DISCO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L152C-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L152C_DISCOVERY.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l152xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Example/EWARM
    ./: startup_stm32l152xc.s
  group Drivers/BSP/STM32L152C-Discovery
    ../../../../../../Drivers/BSP/STM32L152C-Discovery/: stm32l152c_discovery.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
