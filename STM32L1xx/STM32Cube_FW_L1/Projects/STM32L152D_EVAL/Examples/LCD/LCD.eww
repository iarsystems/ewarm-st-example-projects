<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/LCD_Contrast_Control/EWARM/LCD_Contrast_Control.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>LCD_Contrast_Control</project>
        <configuration>STM32L152D_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
