# IAR project LCD_Contrast_Control.ewp, settings and files
configuration STM32L152D_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZD ST STM32L152ZD
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: STM32L152xD; USE_HAL_DRIVER; USE_STM32L152D_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L152D_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Log; ..\..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L152D_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l152xd_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Example/EWARM
    ./: startup_stm32l152xd.s
  group Drivers/BSP/STM32L152D_EVAL
    ../../../../../../Drivers/BSP/STM32L152D_EVAL/: stm32l152d_eval.c stm32l152d_eval_glass_lcd.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_pwr.c stm32l1xx_hal_lcd.c stm32l1xx_hal_adc.c stm32l1xx_hal_dma.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
