<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/TIM_InputCapture/EWARM/TIM_InputCapture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/TIM_TimeBase/EWARM/TIM_TimeBase.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TIM_InputCapture</project>
        <configuration>STM32L152D_EVAL</configuration>
      </member>
      <member>
        <project>TIM_TimeBase</project>
        <configuration>STM32L152D_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
