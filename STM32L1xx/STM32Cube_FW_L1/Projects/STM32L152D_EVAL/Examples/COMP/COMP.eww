<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/COMP_AnalogWatchdog/EWARM/COMP_AnalogWatchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>COMP_AnalogWatchdog</project>
        <configuration>STM32L152D_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
