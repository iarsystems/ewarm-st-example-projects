<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SPI_FullDuplex_ComDMA/EWARM/SPI_FullDuplex_ComDMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SPI_FullDuplex_ComIT/EWARM/SPI_FullDuplex_ComIT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SPI_FullDuplex_ComPolling/EWARM/SPI_FullDuplex_ComPolling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SPI_FullDuplex_ComDMA</project>
        <configuration>STM32L152RE_NUCLEO</configuration>
      </member>
      <member>
        <project>SPI_FullDuplex_ComIT</project>
        <configuration>STM32L152RE_NUCLEO</configuration>
      </member>
      <member>
        <project>SPI_FullDuplex_ComPolling</project>
        <configuration>STM32L152RE_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
