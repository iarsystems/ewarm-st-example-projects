<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/OPAMP_Follower/EWARM/OPAMP_Follower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OPAMP_Follower_Init/EWARM/OPAMP_Follower_Init.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>OPAMP_Follower</project>
        <configuration>STM32L152RE_NUCLEO</configuration>
      </member>
      <member>
        <project>OPAMP_Follower_Init</project>
        <configuration>STM32L152RE_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
