<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/COMP_CompareGpioVsVrefInt_IT/EWARM/COMP_CompareGpioVsVrefInt_IT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/COMP_CompareGpioVsVrefInt_IT_Init/EWARM/COMP_CompareGpioVsVrefInt_IT_Init.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/COMP_CompareGpioVsVrefInt_Window_IT/EWARM/COMP_CompareGpioVsVrefInt_Window_IT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>COMP_CompareGpioVsVrefInt_IT</project>
        <configuration>STM32L152RE_NUCLEO</configuration>
      </member>
      <member>
        <project>COMP_CompareGpioVsVrefInt_IT_Init</project>
        <configuration>STM32L152RE_NUCLEO</configuration>
      </member>
      <member>
        <project>COMP_CompareGpioVsVrefInt_Window_IT</project>
        <configuration>STM32L152RE_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
