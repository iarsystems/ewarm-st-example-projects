<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/OPAMP_CALIBRATION/EWARM/OPAMP_CALIBRATION.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>OPAMP_CALIBRATION</project>
        <configuration>STM32L152RE_NUCLEO</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
