<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/EWARM/Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Project</project>
        <configuration>STM32L152D-EVAL</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>STM32L152-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
