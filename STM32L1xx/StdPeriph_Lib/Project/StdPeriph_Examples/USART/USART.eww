<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/USART_TwoBoards/DataExchangeDMA/DataExchangeDMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/USART_TwoBoards/DataExchangeInterrupt/DataExchangeInterrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HyperTerminal_Interrupt/HyperTerminal_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/Printf/Printf.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>DataExchangeDMA</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>DataExchangeDMA</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
      <member>
        <project>DataExchangeInterrupt</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>DataExchangeInterrupt</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
      <member>
        <project>HyperTerminal_Interrupt</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>HyperTerminal_Interrupt</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
      <member>
        <project>Printf</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>Printf</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
