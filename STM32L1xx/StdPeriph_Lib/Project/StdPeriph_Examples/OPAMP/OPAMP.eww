<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/InternalFollower/InternalFollower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OPAMP_NonInverting/OPAMP_NonInverting.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>InternalFollower</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>InternalFollower</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
      <member>
        <project>OPAMP_NonInverting</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>OPAMP_NonInverting</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
