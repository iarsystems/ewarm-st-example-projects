# IAR project CurrentConsumption.ewp, settings and files
configuration STM32L152-EVAL RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152VB ST STM32L152VB
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL
  ICCARM.CCIncludePath2: ; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STM3210E-EVAL.out
  ILINK.IlinkIcfFile: stm32l1xx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L152-EVAL Flash Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  group CMSIS
    ./: system_stm32l1xx.c
  group EWARMv5
    ../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s
  group EWARMv5/Doc
    ./: readme.txt
  group StdPeriph_Driver
    ../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_usart.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval.c stm32l152_eval_glass_lcd.c stm32l152_eval_lcd.c
  group User
    ./: main.c stm32l1xx_it.c stm32l1xx_lowpowerrun_sram.c stm32l1xx_ulp_modes.c
