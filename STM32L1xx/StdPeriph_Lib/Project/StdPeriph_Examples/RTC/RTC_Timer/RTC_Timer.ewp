# IAR project RTC_Timer.ewp, settings and files
configuration STM32L152D-EVAL RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZD ST STM32L152ZD
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_HD; USE_STM32L152D_EVAL
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STM3210E-EVAL.out
  ILINK.IlinkIcfFile: stm32l1xxD_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L152D-EVAL Flash Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: stm32l1xxD_flash.icf
  group CMSIS
    ./: system_stm32l1xx.c
  group Doc
    ./: readme.txt
  group EWARMv5
    ../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_hd.s
  group StdPeriph_Driver
    ../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c stm32l1xx_usart.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c stm32l152d_eval_glass_lcd.c stm32l152d_eval_lcd.c
  group User
    ./: main.c stm32l1xx_it.c
