<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/SPI_TwoBoards/DataExchangeDMA/DataExchangeDMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SPI_TwoBoards/DataExchangeInterrupt/DataExchangeInterrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SPI_EEPROM/SPI_EEPROM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SPI_MSD/SPI_MSD.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>DataExchangeDMA</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>DataExchangeDMA</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
      <member>
        <project>DataExchangeInterrupt</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>DataExchangeInterrupt</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
      <member>
        <project>SPI_EEPROM</project>
        <configuration>STM32L152D-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>SPI_EEPROM</project>
        <configuration>STM32L152D-EVAL RAM Debug</configuration>
      </member>
      <member>
        <project>SPI_MSD</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>SPI_MSD</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
