# IAR project EncryptedDataExchangeInterrupt.ewp, settings and files
configuration STM32L152D-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZD ST STM32L152ZD
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_HD; USE_STM32L152D_EVAL
  ICCARM.CCIncludePath2: ; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32L152D-EVAL.out
  ILINK.IlinkIcfFile: stm32l1xxD_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ./: system_stm32l1xx.c
  group Doc
    ./: readme.txt
  group EWARM
    ../../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_hd.s
  group StdPeriph_Driver
    ../../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group STM32_EVAL
    ../../../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c stm32l152d_eval_fsmc_nor.c stm32l152d_eval_fsmc_sram.c stm32l152d_eval_glass_lcd.c stm32l152d_eval_lcd.c
  group User
    ./: main.c stm32l1xx_it.c
