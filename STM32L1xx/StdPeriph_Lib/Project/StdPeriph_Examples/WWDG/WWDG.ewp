# IAR project WWDG.ewp, settings and files
configuration STM32L152-EVAL RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152VB ST STM32L152VB
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL
  ICCARM.CCIncludePath2: ; ..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STM3210E-EVAL.out
  ILINK.IlinkIcfFile: stm32l1xx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L152-EVAL Flash Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
configuration STM32L152D-EVAL RAM Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152ZD ST STM32L152ZD
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_HD; USE_STM32L152D_EVAL
  ICCARM.CCIncludePath2: ; ..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL
  ILINK.IlinkIcfFile: stm32l1xxD_ram.icf
configuration STM32L152D-EVAL Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152ZD ST STM32L152ZD
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_HD; USE_STM32L152D_EVAL
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: stm32l1xxD_flash.icf
  group CMSIS
    ./: system_stm32l1xx.c
  group Doc
    ./: readme.txt
  group EWARMv5
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s
  group StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval.c
    ../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c
  group User
    ./: main.c stm32l1xx_it.c
