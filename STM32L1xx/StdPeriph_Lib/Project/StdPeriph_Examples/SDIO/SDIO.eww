<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/uSDCard/uSDCard.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>uSDCard</project>
        <configuration>STM32L152D-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
