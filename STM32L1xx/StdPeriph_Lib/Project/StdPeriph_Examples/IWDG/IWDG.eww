<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/IWDG.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>IWDG</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>IWDG</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
