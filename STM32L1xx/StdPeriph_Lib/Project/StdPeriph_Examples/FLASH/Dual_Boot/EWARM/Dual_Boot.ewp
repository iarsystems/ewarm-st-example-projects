# IAR project Dual_Boot.ewp, settings and files
configuration STM32L1XX_HD_BANK1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZD ST STM32L152ZD
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_HD; USE_STM32L152D_EVAL; BOOT_FROM_BANK1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..\; ..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32F10X_XL_BANK1.out
  ILINK.IlinkIcfFile: stm32l1xx_hd_flash_bank1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L1XX_HD_BANK2 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_HD; USE_STM32L152D_EVAL; BOOT_FROM_BANK2
  ILINK.IlinkIcfFile: stm32l1xx_hd_flash_bank2.icf
  group CMSIS
    ../: system_stm32l1xx.c
  group Doc
    ../: readme.txt
  group EWARM
    ../../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_hd.s
  group StdPeriph_Driver
    ../../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_usart.c
  group STM32L152D_EVAL
    ../../../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c stm32l152d_eval_lcd.c
  group User
    ../: main.c stm32l1xx_it.c
