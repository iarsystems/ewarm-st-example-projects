<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/LCD_Blink_Frequency/LCD_Blink_Frequency.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_Contrast_Control/LCD_Contrast_Control.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/LCD_SegmentsDrive/LCD_SegmentsDrive.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>LCD_Blink_Frequency</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>LCD_Blink_Frequency</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
      <member>
        <project>LCD_Contrast_Control</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>LCD_Contrast_Control</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
      <member>
        <project>LCD_SegmentsDrive</project>
        <configuration>STM32L152-EVAL Flash Debug</configuration>
      </member>
      <member>
        <project>LCD_SegmentsDrive</project>
        <configuration>STM32L152-EVAL RAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
