<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/NOR/NOR.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SRAM/SRAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/SRAM_DataMemory/SRAM_DataMemory.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>NOR</project>
        <configuration>STM32L152D-EVAL</configuration>
      </member>
      <member>
        <project>SRAM</project>
        <configuration>STM32L152D-EVAL</configuration>
      </member>
      <member>
        <project>SRAM_DataMemory</project>
        <configuration>STM32L152D-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
