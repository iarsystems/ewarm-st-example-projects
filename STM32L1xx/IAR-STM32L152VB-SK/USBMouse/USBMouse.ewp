# IAR project USBMouse.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152VB ST STM32L152VB
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL; DEBUG=1; EMB_FLASH
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; app\; board\; modules\; ..\..\StdPeriph_Lib\Libraries\STM32L1xx_StdPeriph_Driver\inc\; ..\..\StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32L1xx\Source\Templates\iar\; ..\bsp\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBMouse.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL; DEBUG=1
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: config/stm32l1xx_ram.icf
  group (top)
    app/: main.c stm32l1xx_conf.h
    ./: readme.txt
  group BSP
    ../bsp/: stm32.c
  group CMSIS
    ../../StdPeriph_Lib/Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s
    board/: system_stm32l1xx.c
  group StdPeriph_Driver
    ../../StdPeriph_Lib/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group USB/Class
    app/: hid_mouse.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
  group Vectors
    app/: stm32l1xx_it.c
