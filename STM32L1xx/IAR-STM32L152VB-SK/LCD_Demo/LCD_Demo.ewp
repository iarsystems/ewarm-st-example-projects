# IAR project LCD_Demo.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152VB ST STM32L152VB
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL; DEBUG=1
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; ; app\; board\; modules\; ..\..\StdPeriph_Lib\Libraries\STM32L1xx_StdPeriph_Driver\inc\; ..\..\StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32L1xx\Source\Templates\iar\; ..\bsp\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/stm32l1xx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL; DEBUG=1; EMB_FLASH
  ILINK.IlinkIcfFile: config/stm32l1xx_flash.icf
configuration Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL; EMB_FLASH; NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config/stm32l1xx_flash.icf
  group (top)
    ./: main.c readme.txt stm32l1xx_conf.h
  group BSP
    ../bsp/: stm32.c stm32_glass_lcd.c
  group CMSIS
    ../../StdPeriph_Lib/Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s
    board/: system_stm32l1xx.c
  group Other
    config/: stm32l1xx_flash.icf stm32l1xx_ram.icf
  group StdPeriph_Driver
    ../../StdPeriph_Lib/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Vectors
    ./: stm32l1xx_it.c
