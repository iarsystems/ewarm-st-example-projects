# IAR project Magnetometer.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152VB ST STM32L152VB
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ; framework\; board\; modules\; ..\..\StdPeriph_Lib\Libraries\STM32L1xx_StdPeriph_Driver\inc\; ..\..\StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32L1xx\Source\Templates\iar\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Magnetometer.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c readme.txt stm32l1xx_conf.h
  group BSP
    board/: board_def.c
  group CMSIS
    ../../StdPeriph_Lib/Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s
    board/: system_stm32l1xx.c
  group framework
    framework/: connect.c fw_config.h gpio.h i2c.h ifpins.h mod.h spi.h uext.h
  group framework/platform
    framework/platform/: platform_config.h stm32_gpio.c stm32_i2c.c stm32_spi.c
  group modules
    modules/: Console_5x7.c mod_lcd3310.c mod_mag3110.c
  group StdPeriph_Driver
    ../../StdPeriph_Lib/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group vectors
    ./: stm32l1xx_it.c
