<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/HRTIM_Arbitrary_Waveform/EWARM/HRTIM_Arbitrary_Waveform.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_DAC_ADC_Interconnect/EWARM/HRTIM_DAC_ADC_Interconnect.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_ExternalEvents/EWARM/HRTIM_ExternalEvents.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_FaultEvent/EWARM/HRTIM_FaultEvent.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_MultiplePWM/EWARM/HRTIM_MultiplePWM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HRTIM_PWM_DifferentFrequencies/EWARM/HRTIM_PWM_DifferentFrequencies.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>HRTIM_Arbitrary_Waveform</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>HRTIM_DAC_ADC_Interconnect</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>HRTIM_ExternalEvents</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>HRTIM_FaultEvent</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>HRTIM_MultiplePWM</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>HRTIM_PWM_DifferentFrequencies</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
