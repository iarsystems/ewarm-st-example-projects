<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/MDMA_LinkedList/EWARM/MDMA_LinkedList.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>MDMA_LinkedList</project>
        <configuration>STM32H743ZI_Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
