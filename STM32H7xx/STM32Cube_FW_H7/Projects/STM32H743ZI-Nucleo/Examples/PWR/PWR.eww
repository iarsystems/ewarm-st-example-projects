<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/PWR_Domain3SystemControl/EWARM/PWR_Domain3SystemControl.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STANDBY/EWARM/PWR_STANDBY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STANDBY_RTC/EWARM/PWR_STANDBY_RTC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STOP_DataRetain/EWARM/PWR_STOP_DataRetain.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/PWR_STOP_RTC/EWARM/PWR_STOP_RTC.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>PWR_Domain3SystemControl</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>PWR_STANDBY</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>PWR_STANDBY_RTC</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>PWR_STOP_DataRetain</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>PWR_STOP_RTC</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
