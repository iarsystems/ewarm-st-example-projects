<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/DMAMUX_RequestGen/EWARM/DMAMUX_RequestGen.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>DMAMUX_RequestGen</project>
        <configuration>STM32H743ZI_Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
