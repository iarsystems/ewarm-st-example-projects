<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/ADC_AnalogWatchdog/EWARM/ADC_AnalogWatchdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DAC_Interconnect/EWARM/ADC_DAC_Interconnect.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DifferentialMode/EWARM/ADC_DifferentialMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DMA_Transfer/EWARM/ADC_DMA_Transfer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_DualModeInterleaved/EWARM/ADC_DualModeInterleaved.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_InternalChannelConversion/EWARM/ADC_InternalChannelConversion.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_OverSampler/EWARM/ADC_OverSampler.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_RegularConversion_Polling/EWARM/ADC_RegularConversion_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/ADC_Regular_injected_groups/EWARM/ADC_Regular_injected_groups.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ADC_AnalogWatchdog</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_DAC_Interconnect</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_DifferentialMode</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_DMA_Transfer</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_DualModeInterleaved</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_InternalChannelConversion</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_OverSampler</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_RegularConversion_Polling</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
      <member>
        <project>ADC_Regular_injected_groups</project>
        <configuration>STM32H743ZI-Nucleo</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
