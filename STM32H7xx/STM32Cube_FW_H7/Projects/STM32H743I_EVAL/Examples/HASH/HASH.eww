<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/HASH_HMAC_SHA1MD5/EWARM/HASH_HMAC_SHA1MD5.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HASH_SHA1MD5/EWARM/HASH_SHA1MD5.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HASH_SHA1MD5_DMA/EWARM/HASH_SHA1MD5_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/HASH_SHA224SHA256_DMA/EWARM/HASH_SHA224SHA256_DMA.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>HASH_HMAC_SHA1MD5</project>
        <configuration>STM32H753I_EVAL</configuration>
      </member>
      <member>
        <project>HASH_SHA1MD5</project>
        <configuration>STM32H753I_EVAL</configuration>
      </member>
      <member>
        <project>HASH_SHA1MD5_DMA</project>
        <configuration>STM32H753I_EVAL</configuration>
      </member>
      <member>
        <project>HASH_SHA224SHA256_DMA</project>
        <configuration>STM32H753I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
