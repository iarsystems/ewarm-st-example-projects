<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/FDCAN_Clock_calibration/EWARM/FDCAN_Clock_calibration.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FDCAN_Com_IT/EWARM/FDCAN_Com_IT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FDCAN_Com_polling/EWARM/FDCAN_Com_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FDCAN_Image_transmission/EWARM/FDCAN_Image_transmission.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/FDCAN_Loopback/EWARM/FDCAN_Loopback.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>FDCAN_Clock_calibration</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>FDCAN_Com_IT</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>FDCAN_Com_polling</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>FDCAN_Image_transmission</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>FDCAN_Loopback</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
