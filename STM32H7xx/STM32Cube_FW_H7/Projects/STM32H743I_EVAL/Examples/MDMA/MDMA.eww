<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/MDMA_DMA2D_Triggering/EWARM/MDMA_DMA2D_Triggering.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/MDMA_GPDMA_Triggering/EWARM/MDMA_GPDMA_Triggering.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/MDMA_LinkedList/EWARM/MDMA_LinkedList.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/MDMA_LinkedList_ColorsComp/EWARM/MDMA_LinkedList_ColorsComp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/MDMA_LTDC_Triggering/EWARM/MDMA_LTDC_Triggering.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/MDMA_RepeatBlock_Rotation/EWARM/MDMA_RepeatBlock_Rotation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/MDMA_RepeatBlock_ZoomOut/EWARM/MDMA_RepeatBlock_ZoomOut.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>MDMA_DMA2D_Triggering</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>MDMA_GPDMA_Triggering</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>MDMA_LinkedList</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>MDMA_LinkedList_ColorsComp</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>MDMA_LTDC_Triggering</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>MDMA_RepeatBlock_Rotation</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>MDMA_RepeatBlock_ZoomOut</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
