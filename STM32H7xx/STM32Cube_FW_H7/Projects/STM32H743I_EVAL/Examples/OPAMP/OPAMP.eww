<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/OPAMP_Follower/EWARM/OPAMP_Follower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/OPAMP_PGA_ExternalBias/EWARM/OPAMP_PGA_ExternalBias.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>OPAMP_Follower</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>OPAMP_PGA_ExternalBias</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
