<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/CRYP_AESCCM_IT/EWARM/CRYP_AESCCM_IT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_AESGCM/EWARM/CRYP_AESGCM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_AESModes/EWARM/CRYP_AESModes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_AESModes_DMA/EWARM/CRYP_AESModes_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/CRYP_TDESModes/EWARM/CRYP_TDESModes.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>CRYP_AESCCM_IT</project>
        <configuration>STM32H753I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AESGCM</project>
        <configuration>STM32H753I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AESModes</project>
        <configuration>STM32H753I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_AESModes_DMA</project>
        <configuration>STM32H753I_EVAL</configuration>
      </member>
      <member>
        <project>CRYP_TDESModes</project>
        <configuration>STM32H753I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
