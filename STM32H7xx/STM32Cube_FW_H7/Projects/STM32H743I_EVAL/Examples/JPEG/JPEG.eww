<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/JPEG_DecodingFromFLASH_DMA/EWARM/JPEG_DecodingFromFLASH_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/JPEG_DecodingUsingFs_DMA/EWARM/JPEG_DecodingUsingFs_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/JPEG_DecodingUsingFs_Interrupt/EWARM/JPEG_DecodingUsingFs_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/JPEG_DecodingUsingFs_Polling/EWARM/JPEG_DecodingUsingFs_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/JPEG_EncodingFromFLASH_DMA/EWARM/JPEG_EncodingFromFLASH_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/JPEG_EncodingUsingFs_DMA/EWARM/JPEG_EncodingUsingFs_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/JPEG_MJPEG_VideoDecoding/EWARM/JPEG_MJPEG_VideoDecoding.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/JPEG_MJPEG_VideoDecodingFromQSPI/EWARM/JPEG_MJPEG_VideoDecodingFromQSPI.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>JPEG_DecodingFromFLASH_DMA</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>JPEG_DecodingUsingFs_DMA</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>JPEG_DecodingUsingFs_Interrupt</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>JPEG_DecodingUsingFs_Polling</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>JPEG_EncodingFromFLASH_DMA</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>JPEG_EncodingUsingFs_DMA</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>JPEG_MJPEG_VideoDecoding</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>JPEG_MJPEG_VideoDecodingFromQSPI</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
