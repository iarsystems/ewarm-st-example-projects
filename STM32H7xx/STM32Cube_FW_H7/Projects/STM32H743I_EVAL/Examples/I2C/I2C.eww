<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/I2C_EEPROM_fast_mode_plus/EWARM/I2C_EEPROM_fast_mode_plus.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/I2C_WakeUpFromStop/EWARM/I2C_WakeUpFromStop.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>I2C_EEPROM_fast_mode_plus</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>I2C_WakeUpFromStop</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
