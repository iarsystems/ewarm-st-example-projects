<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/LPUART_WakeUpFromStop/EWARM/LPUART_WakeUpFromStop.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_HyperTerminal_DMA/EWARM/UART_HyperTerminal_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_HyperTerminal_IT/EWARM/UART_HyperTerminal_IT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_Printf/EWARM/UART_Printf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/UART_WakeUpFromStopUsingFIFO/EWARM/UART_WakeUpFromStopUsingFIFO.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>LPUART_WakeUpFromStop</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>UART_HyperTerminal_DMA</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>UART_HyperTerminal_IT</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>UART_Printf</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
      <member>
        <project>UART_WakeUpFromStopUsingFIFO</project>
        <configuration>STM32H743I_EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
